Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 42df0bfc-382d-40bc-bc57-48f45f4b6224, NumberOfSaves: 405], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Default Site]
File name: 24001L
Time: 2024-12-09T18:19:07+02:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.5.432 (ENU) - IFC 24.0.5.432

# IfcProject, 24001L
LongName: METK aretuskeskuse II; Phase: PP

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey: Level:Circle Head - Project Datum (3)
Name | LongName | Elevation (mm)
1. KORRUS | 1. KORRUS | 0
2. KORRUS | 2. KORRUS | 4425
KATUS | KATUS | 8625

# IfcBuildingElementProxy: Betoonkeha:VPA-2 (8)
In: 1. KORRUS
Type - Material: EST. Betoon. Armeeritud. C35/45
Name (Betoonkeha:VPA-2:...) | Group
698183 | Model Group:Mast-A:698185
698199 | Model Group:Mast-A:698201
698215 | Model Group:Mast-A:698217
698304 | Model Group:Mast-B:698306
698490 | Model Group:Mast-B:698492
698525 | Model Group:Mast-C:698527
698661 | Model Group:Mast-C:698663
723690 | Model Group:Mast-A:723678

# IfcBuildingElementProxy: ITKL_1ne-imp-süvis:ITKL_1ne-imp-süvis, IP44 (2)
In: 2. KORRUS
Type - Material: <Unnamed>, UHMW, White, Plastic, Opaque Black
Name (ITKL_1ne-imp-süvis:ITKL_1ne-imp-süvis, IP44:...)
499783
519367

# IfcBuildingElementProxy: ITKL_1ne-liht-pind:ITKL_1ne-liht-pind, IP66, ITKL_1ne-liht-pind:ITKL_1ne-liht-pind, IP66:646184
In: 1. KORRUS
Type - Material: UHMW, White, Plastic, Opaque Black

# IfcBuildingElementProxy: ITKL_pole_kaitsekumm:235/126K (8)
In: 1. KORRUS
Type - Material: <Unnamed>
Name (ITKL_pole_kaitsekumm:235/126K:...) | Group
698186 | Model Group:Mast-A:698185
698202 | Model Group:Mast-A:698201
698218 | Model Group:Mast-A:698217
698307 | Model Group:Mast-B:698306
698493 | Model Group:Mast-B:698492
698528 | Model Group:Mast-C:698527
698664 | Model Group:Mast-C:698663
723692 | Model Group:Mast-A:723678

# IfcBuildingElementProxy: ITKL_reeper:ITKL_reeper, ITKL_reeper:ITKL_reeper:490572
In: 1. KORRUS
Type - Material: <Unnamed>

# IfcBuildingElementProxy: ITKL_seade:ITKL_seade (2)
In: 1. KORRUS
Type - Material: <Unnamed>
Name (ITKL_seade:ITKL_seade:...)
702995
703221

# IfcBuildingElementProxy: ITKL_valgustirenn:ITKL_valgustirenn (4)
In: 2. KORRUS
Type - Material: <Unnamed>
Name (ITKL_valgustirenn:ITKL_valgustirenn:...)
479619
481874
482486
689336

# IfcBuildingElementProxy: Tehomet_A106SK:Tehomet_A106SK (8)
In: 1. KORRUS
Type - Material: <Unnamed>
Name (Tehomet_A106SK:Tehomet_A106SK:...) | Group
698181 | Model Group:Mast-A:698185
698197 | Model Group:Mast-A:698201
698213 | Model Group:Mast-A:698217
698302 | Model Group:Mast-B:698306
698488 | Model Group:Mast-B:698492
698523 | Model Group:Mast-C:698527
698659 | Model Group:Mast-C:698663
723688 | Model Group:Mast-A:723678

# IfcDistributionPort (922)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLE; SystemType: ELECTRICAL
Name
Port_440491_1
Port_442101_1
Port_446686_1
Port_447416_1
Port_447425_1
Port_447434_1
Port_447445_1
Port_447453_1
Port_447465_1
Port_447473_1
Port_447485_1
Port_447495_1
Port_447505_1
Port_447513_1
Port_447523_1
Port_447533_1
Port_447541_1
Port_447551_1
Port_447561_1
Port_447573_1
Port_447583_1
Port_447591_1
Port_447599_1
Port_447609_1
Port_447619_1
Port_447629_1
Port_447639_1
Port_447647_1
Port_447655_1
Port_447667_1
Port_447675_1
Port_447695_1
Port_447703_1
Port_447710_1
Port_447717_1
Port_447727_1
Port_447735_1
Port_447742_1
Port_447749_1
Port_447766_1
Port_447768_1
Port_447769_1
Port_447770_1
Port_447805_1
Port_447827_1
Port_447836_1
Port_447848_1
Port_447858_1
Port_447866_1
Port_447874_1
Port_447882_1
Port_447898_1
Port_447921_1
Port_447929_1
Port_447937_1
Port_447982_1
Port_447984_1
Port_447985_1
Port_447986_1
Port_448003_1
Port_448022_1
Port_448040_1
Port_448041_1
Port_448499_1
Port_448572_1
Port_448613_1
Port_448638_1
Port_448686_1
Port_448727_1
Port_448788_1
Port_448843_1
Port_448864_1
Port_448912_1
Port_448947_1
Port_448981_1
Port_449002_1
Port_449097_1
Port_449220_1
Port_449339_1
Port_449340_1
Port_449376_1
Port_449409_1
Port_449419_1
Port_449433_1
Port_449441_1
Port_449461_1
Port_449462_1
Port_449463_1
Port_449464_1
Port_449465_1
Port_449556_1
Port_449579_1
Port_449605_1
Port_449606_1
Port_449614_1
Port_449615_1
Port_449623_1
Port_449624_1
Port_449688_1
Port_449722_1
Port_459735_1
Port_459806_1
Port_459846_1
Port_459865_1
Port_459890_1
Port_459891_1
Port_459910_1
Port_459911_1
Port_459914_1
Port_459915_1
Port_459923_1
Port_459924_1
Port_459925_1
Port_459926_1
Port_459927_1
Port_459928_1
Port_459936_1
Port_459937_1
Port_459938_1
Port_459939_1
Port_459940_1
Port_459941_1
Port_459953_1
Port_459954_1
Port_459957_1
Port_459958_1
Port_459968_1
Port_459969_1
Port_459970_1
Port_459971_1
Port_459972_1
Port_459973_1
Port_459981_1
Port_459982_1
Port_459983_1
Port_459984_1
Port_459985_1
Port_459986_1
Port_459994_1
Port_459995_1
Port_459996_1
Port_459997_1
Port_459998_1
Port_459999_1
Port_460044_1
Port_460077_1
Port_460173_1
Port_460174_1
Port_460236_1
Port_460237_1
Port_460238_1
Port_460239_1
Port_460240_1
Port_460241_1
Port_460253_1
Port_460254_1
Port_460255_1
Port_460256_1
Port_460257_1
Port_460258_1
Port_460270_1
Port_460271_1
Port_460281_1
Port_460282_1
Port_460285_1
Port_460286_1
Port_460307_1
Port_460314_1
Port_460410_1
Port_460454_1
Port_460560_1
Port_460561_1
Port_460612_1
Port_460613_1
Port_461746_1
Port_462278_1
Port_462286_1
Port_462294_1
Port_463650_2
Port_464384_2
Port_464463_2
Port_464547_2
Port_464824_2
Port_464858_1
Port_465109_1
Port_465267_1
Port_465401_1
Port_465492_1
Port_465517_1
Port_465532_1
Port_465559_1
Port_465560_1
Port_465590_1
Port_465616_1
Port_465643_1
Port_465736_2
Port_465818_2
Port_465930_2
Port_466659_1
Port_466660_1
Port_466696_1
Port_466697_1
Port_466705_1
Port_466706_1
Port_466716_1
Port_466717_1
Port_466729_1
Port_466730_1
Port_466740_1
Port_466741_1
Port_466749_1
Port_466750_1
Port_466782_1
Port_466783_1
Port_466813_1
Port_466814_1
Port_466879_1
Port_466880_1
Port_466947_1
Port_466948_1
Port_466958_1
Port_468173_1
Port_468238_1
Port_468246_1
Port_468256_1
Port_468270_1
Port_468291_1
Port_468317_1
Port_468327_1
Port_468339_1
Port_468349_1
Port_468359_1
Port_468367_1
Port_468397_1
Port_468424_1
Port_468434_1
Port_468456_1
Port_468472_1
Port_468484_1
Port_468494_1
Port_468504_1
Port_468516_1
Port_468524_1
Port_468532_1
Port_468542_1
Port_468552_1
Port_468562_1
Port_468572_1
Port_468582_1
Port_468596_1
Port_468608_1
Port_468620_1
Port_468630_1
Port_468640_1
Port_468662_1
Port_470638_1
Port_470666_1
Port_470780_1
Port_470788_1
Port_470798_1
Port_470819_1
Port_470825_1
Port_470835_1
Port_470847_1
Port_470857_1
Port_470879_1
Port_470897_1
Port_470898_1
Port_470899_1
Port_470900_1
Port_470901_1
Port_470902_1
Port_470903_1
Port_470922_1
Port_470949_1
Port_470959_1
Port_470983_1
Port_471009_1
Port_471023_1
Port_471049_1
Port_471050_1
Port_471051_1
Port_471052_1
Port_471053_1
Port_471054_1
Port_471078_1
Port_471079_1
Port_471080_1
Port_471081_1
Port_471082_1
Port_471083_1
Port_471098_1
Port_471106_1
Port_471129_1
Port_471139_1
Port_471147_1
Port_471159_1
Port_471169_1
Port_471179_1
Port_471199_1
Port_471207_1
Port_471217_1
Port_471231_1
Port_471239_1
Port_471253_1
Port_471263_1
Port_471285_1
Port_471293_1
Port_471330_1
Port_471354_1
Port_471362_1
Port_471370_1
Port_471391_1
Port_471392_1
Port_471393_1
Port_471394_1
Port_471395_1
Port_471396_1
Port_471397_1
Port_471398_1
Port_471399_1
Port_471419_1
Port_471438_1
Port_471452_1
Port_471462_1
Port_471472_1
Port_471482_1
Port_471490_1
Port_471504_1
Port_471532_1
Port_471542_1
Port_471556_1
Port_471584_1
Port_471650_1
Port_471669_1
Port_471675_1
Port_471689_1
Port_471724_1
Port_471725_1
Port_471763_1
Port_471791_1
Port_471823_1
Port_471829_1
Port_471956_2
Port_472051_1
Port_472058_1
Port_472065_1
Port_472072_1
Port_472105_1
Port_472128_1
Port_472138_1
Port_472148_1
Port_472180_1
Port_472208_1
Port_472216_1
Port_472239_1
Port_472240_1
Port_472268_1
Port_472269_1
Port_472279_1
Port_472280_1
Port_472288_1
Port_472289_1
Port_472303_1
Port_472304_1
Port_472344_1
Port_472352_1
Port_472381_1
Port_472396_1
Port_472407_1
Port_472434_1
Port_472457_1
Port_472476_1
Port_472477_1
Port_472734_1
Port_472735_1
Port_472755_1
Port_472776_1
Port_472798_1
Port_472799_1
Port_472846_1
Port_472982_1
Port_472983_1
Port_472984_1
Port_472985_1
Port_472986_1
Port_472987_1
Port_473061_1
Port_473074_1
Port_473081_1
Port_473779_1
Port_473811_1
Port_473834_1
Port_476431_1
Port_481248_1
Port_481262_1
Port_481270_1
Port_481390_1
Port_482382_1
Port_484447_1
Port_484600_1
Port_485308_1
Port_485309_1
Port_485331_1
Port_485447_1
Port_485486_1
Port_491641_1
Port_491654_1
Port_491667_1
Port_491676_1
Port_491685_1
Port_491696_1
Port_491707_1
Port_492428_2
Port_492600_2
Port_492878_2
Port_493197_2
Port_493310_2
Port_493376_2
Port_493691_2
Port_493832_2
Port_493951_2
Port_494114_2
Port_494247_2
Port_494451_2
Port_494935_2
Port_495011_2
Port_495115_2
Port_495195_2
Port_495300_2
Port_495372_2
Port_495485_2
Port_496118_1
Port_496196_1
Port_496210_1
Port_496220_1
Port_496232_1
Port_496240_1
Port_496258_1
Port_496266_1
Port_496320_1
Port_496356_1
Port_496364_1
Port_496376_1
Port_496392_1
Port_496418_1
Port_496560_1
Port_496741_1
Port_497593_1
Port_497629_1
Port_497638_1
Port_497647_1
Port_497681_1
Port_497706_1
Port_497762_1
Port_497945_1
Port_498038_1
Port_498059_1
Port_498107_1
Port_498120_1
Port_498129_1
Port_498142_1
Port_498183_1
Port_498339_1
Port_498355_1
Port_498728_1
Port_498998_1
Port_499271_1
Port_499279_1
Port_499783_1
Port_509873_1
Port_509995_1
Port_510005_1
Port_510053_1
Port_510077_1
Port_515342_1
Port_515419_1
Port_515574_1
Port_515588_1
Port_515647_1
Port_516009_2
Port_516716_2
Port_516966_1
Port_517296_1
Port_517670_1
Port_517679_1
Port_517690_1
Port_517701_1
Port_517716_1
Port_517729_1
Port_517740_1
Port_517755_1
Port_517972_2
Port_517980_2
Port_517990_2
Port_518000_2
Port_518014_2
Port_518030_2
Port_518044_2
Port_518060_2
Port_518148_2
Port_518258_1
Port_518617_1
Port_518706_2
Port_518745_2
Port_519367_1
Port_521568_1
Port_521759_1
Port_522237_1
Port_522485_1
Port_523429_1
Port_523612_1
Port_523814_1
Port_523822_1
Port_524057_1
Port_524201_1
Port_524273_1
Port_524546_1
Port_524688_1
Port_524812_1
Port_525264_1
Port_525350_1
Port_525518_2
Port_526549_1
Port_526641_1
Port_526801_1
Port_526983_1
Port_527651_1
Port_528220_1
Port_528668_1
Port_529232_1
Port_529240_1
Port_529376_1
Port_529868_1
Port_529986_1
Port_530979_1
Port_531051_1
Port_531376_1
Port_531474_1
Port_532044_1
Port_532469_1
Port_533096_1
Port_533223_2
Port_533230_2
Port_533243_2
Port_533252_2
Port_533261_2
Port_533270_2
Port_533279_2
Port_533335_2
Port_536224_1
Port_536378_1
Port_536659_1
Port_536917_1
Port_536939_1
Port_536989_1
Port_537181_1
Port_537373_1
Port_537620_1
Port_537680_1
Port_537725_1
Port_537738_1
Port_537772_1
Port_537972_1
Port_538019_1
Port_538249_1
Port_538331_1
Port_538347_1
Port_538374_1
Port_538419_1
Port_538526_1
Port_538646_1
Port_538662_1
Port_538812_1
Port_538918_1
Port_538974_1
Port_540077_1
Port_540414_2
Port_540665_1
Port_540702_1
Port_540767_1
Port_540832_1
Port_540882_1
Port_540917_1
Port_541214_1
Port_541232_1
Port_541537_1
Port_541659_1
Port_542073_1
Port_542529_1
Port_542545_1
Port_542603_1
Port_542613_1
Port_542621_1
Port_542635_1
Port_542655_1
Port_542693_1
Port_542765_1
Port_542806_1
Port_573505_1
Port_582993_1
Port_583057_1
Port_583066_1
Port_583150_1
Port_583159_1
Port_583170_1
Port_583179_1
Port_583221_1
Port_583230_1
Port_583241_1
Port_583250_1
Port_583302_1
Port_583315_1
Port_583353_1
Port_583371_1
Port_583380_1
Port_583391_1
Port_583422_1
Port_583433_1
Port_583464_1
Port_583473_1
Port_583506_1
Port_583515_1
Port_583567_1
Port_583576_1
Port_583585_1
Port_583594_1
Port_583603_1
Port_583614_1
Port_583623_1
Port_583632_1
Port_583643_1
Port_583654_1
Port_583663_1
Port_583672_1
Port_583681_1
Port_583690_1
Port_583701_1
Port_583710_1
Port_583721_1
Port_583730_1
Port_583739_1
Port_583748_1
Port_583757_1
Port_583766_1
Port_583775_1
Port_583784_1
Port_583795_1
Port_583802_1
Port_590435_1
Port_590539_1
Port_590550_1
Port_590559_1
Port_590572_1
Port_590581_1
Port_590590_1
Port_590599_1
Port_590610_1
Port_590619_1
Port_590630_1
Port_590641_1
Port_590652_1
Port_590661_1
Port_591215_1
Port_591226_1
Port_591237_1
Port_591248_1
Port_591268_1
Port_591279_1
Port_597944_1
Port_597955_1
Port_597966_1
Port_597975_1
Port_597984_1
Port_597991_1
Port_598002_1
Port_598011_1
Port_598022_1
Port_598029_1
Port_598040_1
Port_598049_1
Port_598060_1
Port_598069_1
Port_598078_1
Port_598087_1
Port_598098_1
Port_598109_1
Port_598120_1
Port_598129_1
Port_598140_1
Port_598149_1
Port_598160_1
Port_598169_1
Port_598182_1
Port_598193_1
Port_598206_1
Port_598215_1
Port_598224_1
Port_598233_1
Port_598242_1
Port_598251_1
Port_598448_1
Port_598539_1
Port_598548_1
Port_598557_1
Port_598572_1
Port_598581_1
Port_598592_1
Port_598599_1
Port_598608_1
Port_598617_1
Port_598626_1
Port_598635_1
Port_598646_1
Port_606054_1
Port_606110_1
Port_606118_1
Port_606126_1
Port_606582_1
Port_606583_1
Port_606584_1
Port_606585_1
Port_606593_1
Port_606594_1
Port_606595_1
Port_606596_1
Port_606619_1
Port_606620_1
Port_606621_1
Port_606622_1
Port_606632_1
Port_606633_1
Port_606634_1
Port_606635_1
Port_608876_1
Port_616549_1
Port_616557_1
Port_616565_1
Port_616573_1
Port_616581_1
Port_616589_1
Port_616599_1
Port_616607_1
Port_619291_1
Port_625727_1
Port_625914_1
Port_626227_1
Port_626228_1
Port_626280_1
Port_626281_1
Port_626291_1
Port_626292_1
Port_626382_1
Port_626389_1
Port_626486_1
Port_626561_1
Port_626562_1
Port_626567_1
Port_626568_1
Port_626571_1
Port_626572_1
Port_626815_1
Port_626892_1
Port_627538_1
Port_627705_1
Port_628021_1
Port_628086_1
Port_628087_1
Port_628090_1
Port_628104_1
Port_628228_1
Port_628888_1
Port_628889_1
Port_628890_1
Port_628891_1
Port_628892_1
Port_628893_1
Port_629737_1
Port_629745_1
Port_630145_2
Port_630267_2
Port_630356_2
Port_630545_1
Port_630546_1
Port_631485_1
Port_631755_1
Port_631765_1
Port_631809_1
Port_631923_1
Port_632004_1
Port_632027_1
Port_632292_1
Port_632346_1
Port_632401_1
Port_632530_1
Port_632531_1
Port_634591_2
Port_634713_2
Port_634870_1
Port_635323_1
Port_635520_1
Port_638506_1
Port_638531_1
Port_638553_1
Port_638554_1
Port_638568_1
Port_638569_1
Port_638581_1
Port_638582_1
Port_638592_1
Port_638593_1
Port_638625_1
Port_638658_1
Port_638670_1
Port_638763_1
Port_638772_1
Port_638785_1
Port_638794_1
Port_638813_1
Port_638815_1
Port_638817_1
Port_638819_1
Port_638837_1
Port_638863_1
Port_638902_1
Port_638942_1
Port_639149_1
Port_639210_1
Port_639218_1
Port_639246_1
Port_640517_1
Port_640680_1
Port_640833_1
Port_640841_1
Port_640864_1
Port_640865_1
Port_640905_1
Port_640941_1
Port_640942_1
Port_641002_1
Port_641052_1
Port_641120_1
Port_641306_2
Port_641539_2
Port_641825_1
Port_642054_2
Port_642270_2
Port_642413_1
Port_645585_1
Port_645638_1
Port_645658_1
Port_645693_1
Port_645715_1
Port_645755_1
Port_645786_1
Port_645787_1
Port_645846_1
Port_646168_1
Port_646184_1
Port_646291_1
Port_646551_1
Port_646567_1
Port_646908_1
Port_647224_1
Port_648003_1
Port_648011_1
Port_648056_1
Port_648101_1
Port_648239_1
Port_648257_1
Port_648270_1
Port_648281_1
Port_648294_1
Port_648305_1
Port_648318_1
Port_648329_1
Port_648340_1
Port_648351_1
Port_648362_1
Port_648377_1
Port_648388_1
Port_648399_1
Port_648410_1
Port_648774_1
Port_648804_1
Port_649701_1
Port_649922_1
Port_650051_2
Port_661277_2
Port_661353_2
Port_661408_2
Port_661732_1
Port_684975_1
Port_685645_1
Port_685801_1
Port_685890_1
Port_687112_1
Port_687151_1
Port_687161_1
Port_687169_1
Port_687179_1
Port_687263_1
Port_687438_1
Port_687496_1
Port_687783_1
Port_687928_1
Port_688195_1
Port_688270_1
Port_688314_1
Port_688390_1
Port_688413_1
Port_691195_1
Port_691312_1
Port_710519_2
Port_710660_2
Port_710674_2
Port_710684_2
Port_712875_1
Port_718787_1
Port_719126_1
Port_719204_1
Port_719205_1

# IfcLightFixture: ITKL_leedprofiil:LP1 Leed-riba, pinnapealne (24)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 900_Tootja: Inventronics + Barthelme
Name (ITKL_leedprofiil:LP1 Leed-riba, pinnapealne:...)
463650
464384
464463
464547
464824
492428
492600
492878
493197
493310
493376
493691
493832
493951
494114
494247
494451
494935
495011
495115
495195
495300
495372
495485

# IfcLightFixture: ITKL_leedprofiil:LP2 Leed-riba, 927, saun (6)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 900_Tootja: Inventronics; 905_Mudel: TEC FLEX Shortpitch Protect TFP600S-G1 -927-05
Name (ITKL_leedprofiil:LP2 Leed-riba, 927, saun:...)
465736
465818
465930
661277
661353
661408

# IfcLightFixture: ITKL_leedprofiil:LP3 Leed-riba, süvistatud, 930 (6)
Type - Material: <Unnamed>
Type - EL_Valgusti - 900_Tootja: Inventronics
Name (ITKL_leedprofiil:LP3 Leed-riba, süvistatud, 930:...) | In
471956 | 2. KORRUS
650051 | KATUS
710519 | KATUS
710660 | KATUS
710674 | KATUS
710684 | KATUS

# IfcLightFixture: ITKL_leedprofiil:LP4 Leed-riba, süvistatud, 940 (32)
Type - Material: <Unnamed>
Type - EL_Valgusti - 900_Tootja: Inventronics + Barthelme; 905_Mudel: TEC FLEX Shortpitch TF1500S-G1 -940-05 +Bardolino Midi T
Name (ITKL_leedprofiil:LP4 Leed-riba, süvistatud, 940:...) | In
516009 | 2. KORRUS
516716 | 2. KORRUS
517972 | 2. KORRUS
517980 | 2. KORRUS
517990 | 2. KORRUS
518000 | 2. KORRUS
518014 | 2. KORRUS
518030 | 2. KORRUS
518044 | 2. KORRUS
518060 | 2. KORRUS
518148 | 2. KORRUS
518706 | 2. KORRUS
518745 | 2. KORRUS
525518 | 1. KORRUS
533223 | 1. KORRUS
533230 | 1. KORRUS
533243 | 1. KORRUS
533252 | 1. KORRUS
533261 | 1. KORRUS
533270 | 1. KORRUS
533279 | 1. KORRUS
533335 | 1. KORRUS
540414 | 1. KORRUS
630145 | 1. KORRUS
630267 | 1. KORRUS
630356 | 1. KORRUS
634591 | 2. KORRUS
634713 | 2. KORRUS
641306 | 1. KORRUS
641539 | 1. KORRUS
642054 | 1. KORRUS
642270 | 1. KORRUS

# IfcLightFixture: ITKL_mudel-EVAK-ring:E6.1 avatud ala, 2W, pinnapealne, IP66 (2)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 003_Osasüsteem: S620 Hädavalgustus; 205_IP_klass: IP65; 305_Võimsus: 2 W; 900_Tootja: AWEX; 905_Mudel: AXN
Name (ITKL_mudel-EVAK-ring:E6.1 avatud ala, 2W, pinnapealne, IP66:...)
648774
648804

# IfcLightFixture: ITKL_mudel-EVAK-ristkülik:E5.1 avatud ala, 2W, pinnapealne (17)
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Evakuatsioonivalgusti; 002_Tähis: E5.1; 003_Osasüsteem: S620 Hädavalgustus; 205_IP_klass: IP40; 300_Paigaldusviis: lakke; 305_Võimsus: 2 W; 900_Tootja: AWEX; 905_Mudel: AXN
Name (ITKL_mudel-EVAK-ristkülik:E5.1 avatud ala, 2W, pinnapealne:...) | In
521568 | 2. KORRUS
521759 | 2. KORRUS
524201 | 1. KORRUS
524273 | 1. KORRUS
524546 | 1. KORRUS
537738 | 1. KORRUS
537772 | 1. KORRUS
537972 | 1. KORRUS
538331 | 2. KORRUS
538347 | 2. KORRUS
538374 | 2. KORRUS
640833 | 2. KORRUS
640841 | 2. KORRUS
640905 | 2. KORRUS
684975 | 2. KORRUS
685645 | 1. KORRUS
687783 | 1. KORRUS

# IfcLightFixture: ITKL_mudel-EVAK-ristkülik:E5.2 avatud ala, 2W, süvistatud (7)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Evakuatsioonivalgusti; 002_Tähis: E5.2; 003_Osasüsteem: S620 Hädavalgustus; 205_IP_klass: IP40; 300_Paigaldusviis: lakke; 305_Võimsus: 2 W; 900_Tootja: AWEX; 905_Mudel: AXN
Name (ITKL_mudel-EVAK-ristkülik:E5.2 avatud ala, 2W, süvistatud:...)
536939
536989
537181
537373
537620
537680
688270

# IfcLightFixture: ITKL_mudel-EVAK-ristkülik:E7.1 Avatud ala lääts, 1W, ribade vahel (23)
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Evakuatsioonivalgusti; 002_Tähis: E7.1; 003_Osasüsteem: S620 Hädavalgustus; 205_IP_klass: IP40; 300_Paigaldusviis: lakke; 305_Võimsus: 3 W; 900_Tootja: AWEX; 905_Mudel: ARROW N
Name (ITKL_mudel-EVAK-ristkülik:E7.1 Avatud ala lääts, 1W, ribade vahel:...) | In
442101 | 1. KORRUS
496118 | 2. KORRUS
496196 | 2. KORRUS
496220 | 2. KORRUS
496232 | 2. KORRUS
496240 | 2. KORRUS
496320 | 2. KORRUS
496356 | 2. KORRUS
496376 | 2. KORRUS
496392 | 2. KORRUS
496418 | 2. KORRUS
496560 | 2. KORRUS
522237 | 1. KORRUS
523612 | 1. KORRUS
523814 | 1. KORRUS
523822 | 1. KORRUS
524057 | 1. KORRUS
536224 | 1. KORRUS
536378 | 1. KORRUS
536659 | 1. KORRUS
537725 | 1. KORRUS
538019 | 2. KORRUS
687263 | 2. KORRUS

# IfcLightFixture: ITKL_mudel-EVAK-ristkülik:E7.2 Avatud ala lääts, 2W, ribade vahel (10)
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Evakuatsioonivalgusti; 002_Tähis: E7.2; 003_Osasüsteem: S620 Hädavalgustus; 205_IP_klass: IP40; 300_Paigaldusviis: lakke; 305_Võimsus: 2 W; 900_Tootja: AWEX; 905_Mudel: ARROW N
Name (ITKL_mudel-EVAK-ristkülik:E7.2 Avatud ala lääts, 2W, ribade vahel:...) | In
440491 | 1. KORRUS
496210 | 2. KORRUS
496258 | 2. KORRUS
496266 | 2. KORRUS
496364 | 2. KORRUS
496741 | 2. KORRUS
522485 | 1. KORRUS
523429 | 1. KORRUS
536917 | 1. KORRUS
538249 | 2. KORRUS

# IfcLightFixture: ITKL_mudel-EVAK-ristkülik:E8.1 assüm, 3W, seinale, IP66 (5)
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Evakuatsioonivalgusti; 002_Tähis: E5.1; 003_Osasüsteem: S620 Hädavalgustus; 205_IP_klass: IP40; 300_Paigaldusviis: lakke; 305_Võimsus: 2 W; 900_Tootja: AWEX; 905_Mudel: OUTDOOR
Name (ITKL_mudel-EVAK-ristkülik:E8.1 assüm, 3W, seinale, IP66:...) | In
648003 | 2. KORRUS
648011 | 2. KORRUS
685890 | 1. KORRUS
687438 | 1. KORRUS
687496 | 1. KORRUS

# IfcLightFixture: ITKL_mudel-ring:C12 ASTER PET FELT , riputatav (2)
In: 2. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP44; 300_Paigaldusviis: lakke; 305_Võimsus: 23 W; 900_Tootja: Refelt; 905_Mudel: ASTER PET FELT LAMP LARGELAMP LARGE
Name (ITKL_mudel-ring:C12 ASTER PET FELT , riputatav:...)
638902
638942

# IfcLightFixture: ITKL_mudel-ring:C6.1 Pleiad 70 (47)
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP44; 300_Paigaldusviis: lakke; 305_Võimsus: 8 W; 900_Tootja: Fagerhult; 905_Mudel: PLEIAD G4 70 REC DALI 651LM MATT MEDIUM HL 830
Name (ITKL_mudel-ring:C6.1 Pleiad 70:...) | In
447695 | 1. KORRUS
447703 | 1. KORRUS
447710 | 1. KORRUS
447717 | 1. KORRUS
447727 | 1. KORRUS
447735 | 1. KORRUS
447742 | 1. KORRUS
447749 | 1. KORRUS
447766 | 1. KORRUS
447768 | 1. KORRUS
447769 | 1. KORRUS
447770 | 1. KORRUS
447805 | 1. KORRUS
447827 | 1. KORRUS
447836 | 1. KORRUS
447848 | 1. KORRUS
447858 | 1. KORRUS
447866 | 1. KORRUS
447874 | 1. KORRUS
447882 | 1. KORRUS
447898 | 1. KORRUS
447921 | 1. KORRUS
447929 | 1. KORRUS
447937 | 1. KORRUS
447982 | 1. KORRUS
447984 | 1. KORRUS
447985 | 1. KORRUS
447986 | 1. KORRUS
448003 | 1. KORRUS
448022 | 1. KORRUS
448040 | 1. KORRUS
448041 | 1. KORRUS
465590 | 1. KORRUS
465616 | 1. KORRUS
471650 | 1. KORRUS
471669 | 2. KORRUS
471675 | 2. KORRUS
471724 | 2. KORRUS
471725 | 2. KORRUS
471763 | 2. KORRUS
471791 | 2. KORRUS
472105 | 2. KORRUS
472128 | 2. KORRUS
472138 | 2. KORRUS
472148 | 2. KORRUS
687928 | 1. KORRUS
688195 | 1. KORRUS

# IfcLightFixture: ITKL_mudel-ring:C6.2 Pleiad 70, 1072lm süvistav (2)
In: 2. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP44; 300_Paigaldusviis: lakke; 305_Võimsus: 12 W; 900_Tootja: Fagerhult; 905_Mudel: PLEIAD G4 70 REC DALI 1073LM MATT MEDIUM HL 830
Name (ITKL_mudel-ring:C6.2 Pleiad 70, 1072lm süvistav:...)
471823
471829

# IfcLightFixture: ITKL_mudel-ring:C7 Touch mini, suunatav (4)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Siinivalgusti; 002_Tähis: C7; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 13 W; 900_Tootja: Fagerhult; 905_Mudel: TOUCH MINI G2 LL 930 XTR WIDE BEAM
Name (ITKL_mudel-ring:C7 Touch mini, suunatav:...)
461746
462278
462286
462294

# IfcLightFixture: ITKL_mudel-ristkülik:C1.1 ILO 50 R 580 HO 940, süvistatud (4)
In: 2. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 18 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R 580 HO 940 OF-60 DALI
Name (ITKL_mudel-ristkülik:C1.1 ILO 50 R 580 HO 940, süvistatud:...)
472051
472058
472065
472072

# IfcLightFixture: ITKL_mudel-ristkülik:C1.4 ILO 50 R 1700 LP 940, süvistatud (8)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 27 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R2400 LP 940 OF-60 DALI
Name (ITKL_mudel-ristkülik:C1.4 ILO 50 R 1700 LP 940, süvistatud:...)
448788
449097
629737
629745
630545
630546
646908
647224

# IfcLightFixture: ITKL_mudel-ristkülik:C1.5 ILO 50 R 2400 LP 940, süvistatud (2)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 38 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R2400 HO 940 OF-60 DALI
Name (ITKL_mudel-ristkülik:C1.5 ILO 50 R 2400 LP 940, süvistatud:...)
448572
448864

# IfcLightFixture: ITKL_mudel-ristkülik:C1.6 ILO 50 R 2820 LP 940, süvistatud (11)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 44 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R2820 HO 940 OF-60 DALI
Name (ITKL_mudel-ristkülik:C1.6 ILO 50 R 2820 LP 940, süvistatud:...)
448499
448613
448638
448686
448727
448843
448912
448947
448981
449002
449722

# IfcLightFixture: ITKL_mudel-ristkülik:C11.1 3F Linda LED 1x24W L1270, pinnapealne (7)
In: 2. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 28 W; 900_Tootja: 3F Filippi; 905_Mudel: 3F Linda LED 1x24W DALI L1270, 58551
Name (ITKL_mudel-ristkülik:C11.1 3F Linda LED 1x24W L1270, pinnapealne:...)
476431
481390
482382
484447
484600
640517
640680

# IfcLightFixture: ITKL_mudel-ristkülik:C11.2 3F Linda LED 2x24W L1270, pinnapealne (8)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 54 W; 900_Tootja: 3F Filippi; 905_Mudel: 3F Linda LED 2x24W L1270
Name (ITKL_mudel-ristkülik:C11.2 3F Linda LED 2x24W L1270, pinnapealne:...)
645585
645638
645658
645693
645715
645755
645786
645787

# IfcLightFixture: ITKL_mudel-ristkülik:C13_Nextrema G3 PAW 40-840 ETDD TWP PC (6)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 002_Tähis: C13; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP66; 300_Paigaldusviis: lakke; 305_Võimsus: 47 W; 900_Tootja: Trilux; 905_Mudel: Nextrema G3 PAW 40-840 ETDD TWP PC
Name (ITKL_mudel-ristkülik:C13_Nextrema G3 PAW 40-840 ETDD TWP PC:...)
459953
459954
459957
459958
626815
626892

# IfcLightFixture: ITKL_mudel-ristkülik:C2.1 ILO 50 PDI 1546 LP 940, riputatud (35)
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 92 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R1546 PDI HO 940 PR DALI
Name (ITKL_mudel-ristkülik:C2.1 ILO 50 PDI 1546 LP 940, riputatud:...) | In
449579 | 1. KORRUS
449606 | 1. KORRUS
449615 | 1. KORRUS
449624 | 1. KORRUS
465560 | 1. KORRUS
472180 | 2. KORRUS
472208 | 2. KORRUS
472216 | 2. KORRUS
472239 | 2. KORRUS
472240 | 2. KORRUS
472268 | 2. KORRUS
472269 | 2. KORRUS
472279 | 2. KORRUS
472280 | 2. KORRUS
472288 | 2. KORRUS
472289 | 2. KORRUS
472303 | 2. KORRUS
472304 | 2. KORRUS
472344 | 2. KORRUS
472352 | 2. KORRUS
472381 | 2. KORRUS
472846 | 2. KORRUS
481248 | 2. KORRUS
481262 | 2. KORRUS
481270 | 2. KORRUS
485331 | 2. KORRUS
626382 | 1. KORRUS
626389 | 1. KORRUS
626571 | 1. KORRUS
626572 | 1. KORRUS
632401 | 2. KORRUS
639246 | 2. KORRUS
640941 | 2. KORRUS
640942 | 2. KORRUS
642413 | 1. KORRUS

# IfcLightFixture: ITKL_mudel-ristkülik:C2.10 ILO 50 PDI LP 940, riputatud (8)
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 16 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R986 PDI LP 940 OF-60 DALI
Name (ITKL_mudel-ristkülik:C2.10 ILO 50 PDI LP 940, riputatud:...) | In
540077 | 1. KORRUS
540665 | 1. KORRUS
540767 | 1. KORRUS
540832 | 1. KORRUS
628104 | 2. KORRUS
628228 | 2. KORRUS
641052 | 1. KORRUS
641825 | 1. KORRUS

# IfcLightFixture: ITKL_mudel-ristkülik:C2.2 ILO 50 PDI 1826 LP 940, riputatud (24)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 55 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R1826 PDI LP 940 PR DALI
Name (ITKL_mudel-ristkülik:C2.2 ILO 50 PDI 1826 LP 940, riputatud:...)
459806
459891
459911
459915
459924
459928
459937
459941
459969
459973
459982
459986
459995
459999
460077
460174
460237
460241
460254
460258
460271
460282
460286
465517

# IfcLightFixture: ITKL_mudel-ristkülik:C2.3 ILO 50 PDI 2036 LP 940, riputatud (17)
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 61 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R2036 PDI LP 940 PR DALI
Name (ITKL_mudel-ristkülik:C2.3 ILO 50 PDI 2036 LP 940, riputatud:...) | In
449339 | 1. KORRUS
449340 | 1. KORRUS
472396 | 2. KORRUS
472434 | 2. KORRUS
472476 | 2. KORRUS
472477 | 2. KORRUS
473834 | 2. KORRUS
626227 | 1. KORRUS
626228 | 1. KORRUS
626280 | 1. KORRUS
626281 | 1. KORRUS
626291 | 1. KORRUS
626292 | 1. KORRUS
626561 | 1. KORRUS
626562 | 1. KORRUS
626567 | 1. KORRUS
626568 | 1. KORRUS

# IfcLightFixture: ITKL_mudel-ristkülik:C2.4 ILO 50 PDI 2176 LP 940, riputatud (5)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 66 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R2176 PDI LP 940 PR DALI
Name (ITKL_mudel-ristkülik:C2.4 ILO 50 PDI 2176 LP 940, riputatud:...)
449556
449605
449614
449623
465559

# IfcLightFixture: ITKL_mudel-ristkülik:C2.5 ILO 50 PDI 2246 LP 940, riputatud (30)
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 68 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R2246 PDI LP 940 PR DALI
Name (ITKL_mudel-ristkülik:C2.5 ILO 50 PDI 2246 LP 940, riputatud:...) | In
459735 | 1. KORRUS
459890 | 1. KORRUS
459910 | 1. KORRUS
459914 | 1. KORRUS
459923 | 1. KORRUS
459927 | 1. KORRUS
459936 | 1. KORRUS
459940 | 1. KORRUS
459968 | 1. KORRUS
459972 | 1. KORRUS
459981 | 1. KORRUS
459985 | 1. KORRUS
459994 | 1. KORRUS
459998 | 1. KORRUS
460236 | 1. KORRUS
460240 | 1. KORRUS
460253 | 1. KORRUS
460257 | 1. KORRUS
460270 | 1. KORRUS
460281 | 1. KORRUS
460285 | 1. KORRUS
465492 | 1. KORRUS
472755 | 2. KORRUS
472776 | 2. KORRUS
472798 | 2. KORRUS
472799 | 2. KORRUS
472986 | 2. KORRUS
472987 | 2. KORRUS
628892 | 2. KORRUS
628893 | 2. KORRUS

# IfcLightFixture: ITKL_mudel-ristkülik:C2.6 ILO 50 PDI 2526 LP 940, riputatud (18)
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 40 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R2526 PDI LP 940 PR DALI
Name (ITKL_mudel-ristkülik:C2.6 ILO 50 PDI 2526 LP 940, riputatud:...) | In
460044 | 1. KORRUS
460173 | 1. KORRUS
460307 | 1. KORRUS
460314 | 1. KORRUS
472407 | 2. KORRUS
472457 | 2. KORRUS
472982 | 2. KORRUS
472983 | 2. KORRUS
472984 | 2. KORRUS
472985 | 2. KORRUS
628888 | 2. KORRUS
628889 | 2. KORRUS
628890 | 2. KORRUS
628891 | 2. KORRUS
632346 | 2. KORRUS
639149 | 2. KORRUS
639210 | 2. KORRUS
639218 | 2. KORRUS

# IfcLightFixture: ITKL_mudel-ristkülik:C2.7 ILO 50 PDI 2806 LP 940, riputatud (34)
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 85 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R2806 PDI LP 940 PR DALI
Name (ITKL_mudel-ristkülik:C2.7 ILO 50 PDI 2806 LP 940, riputatud:...) | In
449220 | 1. KORRUS
449376 | 1. KORRUS
449409 | 1. KORRUS
449419 | 1. KORRUS
449433 | 1. KORRUS
449441 | 1. KORRUS
449461 | 1. KORRUS
449462 | 1. KORRUS
449463 | 1. KORRUS
449464 | 1. KORRUS
449465 | 1. KORRUS
459846 | 1. KORRUS
459865 | 1. KORRUS
459925 | 1. KORRUS
459926 | 1. KORRUS
459938 | 1. KORRUS
459939 | 1. KORRUS
459970 | 1. KORRUS
459971 | 1. KORRUS
459983 | 1. KORRUS
459984 | 1. KORRUS
459996 | 1. KORRUS
459997 | 1. KORRUS
460238 | 1. KORRUS
460239 | 1. KORRUS
460255 | 1. KORRUS
460256 | 1. KORRUS
472734 | 2. KORRUS
472735 | 2. KORRUS
626486 | 1. KORRUS
628021 | 2. KORRUS
628086 | 2. KORRUS
628087 | 2. KORRUS
628090 | 2. KORRUS

# IfcLightFixture: ITKL_mudel-ristkülik:C2.8 ILO 50 HO 2806 LP 940, pinnapealne, ITKL_mudel-ristkülik:C2.8 ILO 50 HO 2806 LP 940, pinnapealne:449688
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 88 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R2806 HO LP 940 PR DALI

# IfcLightFixture: ITKL_mudel-ristkülik:C3.1, ILO 35 C 706 LP 930 OP, pinnapealne, ribade vahel (115)
In: 2. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 11 W; 900_Tootja: Ledluks; 905_Mudel: ILO 35 C 706 HE930 OP DALI
Name (ITKL_mudel-ristkülik:C3.1, ILO 35 C 706 LP 930 OP, pinnapealne, ribade vahel:...)
468173
468238
468246
468256
468270
468291
468317
468327
468339
468349
468359
468367
468397
468424
468434
468456
468472
468484
468494
468504
468516
468524
468532
468542
468552
468562
468572
468582
468596
468608
468620
468630
468640
468662
470638
470666
470780
470788
470798
470819
470825
470835
470847
470857
470879
470897
470898
470899
470900
470901
470902
470903
470922
470949
470959
470983
471009
471023
471049
471050
471051
471052
471053
471054
471078
471079
471080
471081
471082
471083
471098
471106
471129
471139
471147
471159
471169
471179
471199
471207
471217
471231
471239
471253
471263
471285
471293
471330
471354
471362
471370
471391
471392
471393
471394
471395
471396
471397
471398
471399
471419
471438
471452
471462
471472
471482
471490
471504
471532
471542
471556
471584
473779
473811
619291

# IfcLightFixture: ITKL_mudel-ristkülik:C3.12, ILO 35 C 706 HO 930 PR, pinnapealne, ribade vahel (30)
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 22 W; 900_Tootja: Ledluks; 905_Mudel: ILO 35 C 706 HO 930 PR DALI BLACK
Name (ITKL_mudel-ristkülik:C3.12, ILO 35 C 706 HO 930 PR, pinnapealne, ribade vahel:...) | In
638506 | 2. KORRUS
638531 | 2. KORRUS
638553 | 2. KORRUS
638554 | 2. KORRUS
638568 | 2. KORRUS
638569 | 2. KORRUS
638581 | 2. KORRUS
638582 | 2. KORRUS
638592 | 2. KORRUS
638593 | 2. KORRUS
638625 | 2. KORRUS
638658 | 2. KORRUS
638670 | 2. KORRUS
638763 | 2. KORRUS
638772 | 2. KORRUS
638785 | 2. KORRUS
638794 | 2. KORRUS
638813 | 2. KORRUS
638815 | 2. KORRUS
638817 | 2. KORRUS
638819 | 2. KORRUS
638837 | 2. KORRUS
638863 | 2. KORRUS
687112 | 2. KORRUS
687151 | 2. KORRUS
687161 | 2. KORRUS
687169 | 2. KORRUS
687179 | 2. KORRUS
691195 | 1. KORRUS
691312 | 1. KORRUS

# IfcLightFixture: ITKL_mudel-ristkülik:C3.13, ILO 35 C 1056 HO 930 OP, pinnapealne, ribade vahel 2 (2)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 33 W; 900_Tootja: Ledluks; 905_Mudel: ILO 35 C 1056 HO930 OP DALI BLACK
Name (ITKL_mudel-ristkülik:C3.13, ILO 35 C 1056 HO 930 OP, pinnapealne, ribade vahel 2:...)
464858
685801

# IfcLightFixture: ITKL_mudel-ristkülik:C3.2, ILO 35 C 1266 HE 930 OP, pinnapealne, ribade vahel (29)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 28 W; 900_Tootja: Ledluks; 905_Mudel: ILO 35 C 1266 HE930 OP DALI BLACK
Name (ITKL_mudel-ristkülik:C3.2, ILO 35 C 1266 HE 930 OP, pinnapealne, ribade vahel:...)
446686
447416
447425
447434
447445
447453
447465
447473
447485
447495
447505
447513
447523
447533
447541
447551
447561
447573
447583
447591
447599
447609
447619
447629
447639
447647
447655
447667
447675

# IfcLightFixture: ITKL_mudel-ristkülik:C3.3, ILO 35 C 1546 LP 930 OP, pinnapealne (2)
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 24 W; 900_Tootja: Ledluks; 905_Mudel: ILO 35 C 1826 LP 930 OP DALI
Name (ITKL_mudel-ristkülik:C3.3, ILO 35 C 1546 LP 930 OP, pinnapealne:...) | In
465532 | 1. KORRUS
473061 | 2. KORRUS

# IfcLightFixture: ITKL_mudel-ristkülik:C3.4, ILO 35 C 1546 HE 930 OP, pinnapealne (2)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 35 W; 900_Tootja: Ledluks; 905_Mudel: ILO 35 C 1546 HE 930 OP DALI
Name (ITKL_mudel-ristkülik:C3.4, ILO 35 C 1546 HE 930 OP, pinnapealne:...)
465267
465401

# IfcLightFixture: ITKL_mudel-ristkülik:C3.5, ILO 35 C 1546 HO 930 OP, pinnapealne (2)
In: 2. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 57 W; 900_Tootja: Ledluks; 905_Mudel: ILO 35 C 1826 HO 930 OP FO BLACK
Name (ITKL_mudel-ristkülik:C3.5, ILO 35 C 1546 HO 930 OP, pinnapealne:...)
473074
473081

# IfcLightFixture: ITKL_mudel-ristkülik:C3.6 ILO 50 C 1546 HE 940 PR, pinnapealne (4)
In: 2. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 305_Võimsus: 35 W; 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 900_Tootja: Ledluks; 905_Mudel: ILO 50 C 1546 HE 940 PR DALI
Name (ITKL_mudel-ristkülik:C3.6 ILO 50 C 1546 HE 940 PR, pinnapealne:...)
718787
719126
719204
719205

# IfcLightFixture: ITKL_mudel-ristkülik:C3.8 ILO 50 C 2546 LP 940 PR, pinnapealne (6)
In: 2. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 305_Võimsus: 40 W; 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 900_Tootja: Ledluks; 905_Mudel: ILO 50 C 2526 LO 940 PR DALI
Name (ITKL_mudel-ristkülik:C3.8 ILO 50 C 2546 LP 940 PR, pinnapealne:...)
485308
485309
632530
632531
640864
640865

# IfcLightFixture: ITKL_mudel-ristkülik:C3.9 ILO 50 PDI 1546 HO 930 PR, riputatud, ITKL_mudel-ristkülik:C3.9 ILO 50 PDI 1546 HO 930 PR, riputatud:471689
In: 2. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 48 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 PDI 1546 HO 930 PR DALI

# IfcLightFixture: ITKL_mudel-ristkülik:C4.1 ILO 50 R 2680 HO OP 940, süvistatud (3)
In: 2. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 83 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R 2680 930 MOD-60 DALI BLACK-BG
Name (ITKL_mudel-ristkülik:C4.1 ILO 50 R 2680 HO OP 940, süvistatud:...)
631923
632004
632027

# IfcLightFixture: ITKL_mudel-ristkülik:C4.2 ILO 50 R 2820 HO OP 930, süvistatud (4)
In: 2. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 88 W; 900_Tootja: Ledluks; 905_Mudel: ILO 50 R 2820 HE 930 MOD-60 DALI BLACK-BG
Name (ITKL_mudel-ristkülik:C4.2 ILO 50 R 2820 HO OP 930, süvistatud:...)
631485
631755
631765
631809

# IfcLightFixture: ITKL_mudel-ristkülik:C5.1 PLAIN 90 PDI 1358 HE 940, riputatud (29)
In: 2. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 56 W; 900_Tootja: Ledluks; 905_Mudel: PLAIN 90 PDI 1358 HE 940 OF-60 DALI
Name (ITKL_mudel-ristkülik:C5.1 PLAIN 90 PDI 1358 HE 940, riputatud:...)
460410
460454
460560
460561
460612
460613
466659
466660
466696
466697
466705
466706
466716
466717
466729
466730
466740
466741
466749
466750
466782
466783
466813
466814
466879
466880
466947
466948
466958

# IfcLightFixture: ITKL_mudel-ristkülik:C9 Allfive 1200 ON/OFF LL Prism 840, pinnapealne (2)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Sisevalgusti; 003_Osasüsteem: S251 Sisevalgustus; 205_IP_klass: IP20; 300_Paigaldusviis: lakke; 305_Võimsus: 30 W; 900_Tootja: Fagerhult; 905_Mudel: Allfive 1200 ON/OFF LL Prism 840
Name (ITKL_mudel-ristkülik:C9 Allfive 1200 ON/OFF LL Prism 840, pinnapealne:...)
465109
465643

# IfcLightFixture: Louispoulsen_FlindtGardenBollard:Louispoulsen_FlindtGardenBollard (77)
In: 1. KORRUS
Type - Material: Louis Poulsen - ALU COL TEXT - 162
Type - EL_Valgusti - 001_Nimetus: Pollarvalgusti; 002_Tähis: P1; 003_Osasüsteem: S252 Välisvalgustus; 205_IP_klass: IP65; 300_Paigaldusviis: maapind; 305_Võimsus: 8.8 W; 900_Tootja: Louis Poulsen; 905_Mudel: Flindt Garden Bollard
Name (Louispoulsen_FlindtGardenBollard:Louispoulsen_FlindtGardenBollard:...)
560618
563085
567834
567842
567850
567959
567969
567979
568790
568824
568878
568925
569053
569071
569079
569087
569095
569103
570237
570245
570253
571994
572199
572209
572225
572322
572332
572342
572352
572360
572368
572378
572388
572396
572404
572412
572420
572428
572436
601600
601610
601620
601630
601709
601732
601744
601754
601953
601963
601973
602277
602303
602578
602594
602899
602907
602915
602923
602933
602941
602949
668191
668285
668328
668358
668451
668834
668854
668868
668878
673944
674083
674124
674142
674215
674256
676248

# IfcLightFixture: WE-EF_AFL120:WE-EF_AFL120_102-0142_2 (2)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 305_Võimsus: 35 W; 001_Nimetus: Välisvalgusti; 002_Tähis: M3; 003_Osasüsteem: S252 Välisvalgustus; 205_IP_klass: IP66; 300_Paigaldusviis: mastile; 900_Tootja: WE-EF; 905_Mudel: AFL120-WL LED
Name (WE-EF_AFL120:WE-EF_AFL120_102-0142_2:...) | Group
698529 | Model Group:Mast-C:698527
698665 | Model Group:Mast-C:698663

# IfcLightFixture: WE-EF_AFL120:WE-EF_AFL120_102-0346_2 (2)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 305_Võimsus: 35 W; 001_Nimetus: Välisvalgusti; 002_Tähis: M2; 003_Osasüsteem: S252 Välisvalgustus; 205_IP_klass: IP66; 300_Paigaldusviis: mastile; 900_Tootja: WE-EF; 905_Mudel: AFL120-WL LED
Name (WE-EF_AFL120:WE-EF_AFL120_102-0346_2:...) | Group
698308 | Model Group:Mast-B:698306
698494 | Model Group:Mast-B:698492

# IfcLightFixture: WE-EF_AFL120:WE-EF_AFL120_102-0348_2 (4)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 305_Võimsus: 35 W; 001_Nimetus: Välisvalgusti; 002_Tähis: M1; 003_Osasüsteem: S252 Välisvalgustus; 205_IP_klass: IP66; 300_Paigaldusviis: mastile; 900_Tootja: WE-EF; 905_Mudel: AFL120-WL LED
Name (WE-EF_AFL120:WE-EF_AFL120_102-0348_2:...) | Group
698187 | Model Group:Mast-A:698185
698203 | Model Group:Mast-A:698201
698219 | Model Group:Mast-A:698217
723693 | Model Group:Mast-A:723678

# IfcLightFixture: iGuzzini_UE26:iGuzzini_UE26 (115)
In: 1. KORRUS
Type - Material: 13 - Steel, <Unnamed>, Alluminio Grigio 15, Plastica, nero lucido, LED binaco
Type - EL_Valgusti - 001_Nimetus: Fassaadivalgusti; 002_Tähis: OW1; 003_Osasüsteem: S252 Välisvalgustus; 205_IP_klass: IP66; 300_Paigaldusviis: seina; 305_Võimsus: 3.9 W; 900_Tootja: iGuzzini; 905_Mudel: Linealuce - 27 Surface Full Remote
Name (iGuzzini_UE26:iGuzzini_UE26:...)
573505
582993
583057
583066
583150
583159
583170
583179
583221
583230
583241
583250
583302
583315
583353
583371
583380
583391
583422
583433
583464
583473
583506
583515
583567
583576
583585
583594
583603
583614
583623
583632
583643
583654
583663
583672
583681
583690
583701
583710
583721
583730
583739
583748
583757
583766
583775
583784
583795
583802
590435
590539
590550
590559
590572
590581
590590
590599
590610
590619
590630
590641
590652
590661
591215
591226
591237
591248
591268
591279
597944
597955
597966
597975
597984
597991
598002
598011
598022
598029
598040
598049
598060
598069
598078
598087
598098
598109
598120
598129
598140
598149
598160
598169
598182
598193
598206
598215
598224
598233
598242
598251
598448
598539
598548
598557
598572
598581
598592
598599
598608
598617
598626
598635
598646

# IfcLightFixture: inventronics_LR-P-1200-930-30S-XX-03:inventronics_LR-P-1200-930-30S-XX-03 (20)
In: 2. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Välisvalgusti; 002_Tähis: OC1; 003_Osasüsteem: S252 Välisvalgustus; 205_IP_klass: IP67; 300_Paigaldusviis: lae; 305_Võimsus: 5.2 W; 900_Tootja: inventronics; 905_Mudel: Finesse
Name (inventronics_LR-P-1200-930-30S-XX-03:inventronics_LR-P-1200-930-30S-XX-03:...)
606054
606110
606118
606126
606582
606583
606584
606585
606593
606594
606595
606596
606619
606620
606621
606622
606632
606633
606634
606635

# IfcLightFixture: inventronics_LR-P-2000-930-WW-XX-05:inventronics_LR-P-2000-930-WW-XX-05 (2)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Välisvalgusti; 002_Tähis: OC2; 003_Osasüsteem: S252 Välisvalgustus; 205_IP_klass: IP67; 300_Paigaldusviis: lae; 305_Võimsus: 14.45 W; 900_Tootja: inventronics; 905_Mudel: Finesse
Name (inventronics_LR-P-2000-930-WW-XX-05:inventronics_LR-P-2000-930-WW-XX-05:...)
625727
625914

# IfcLightFixture: inventronics_LR-P-900-930-WW-XX-11:inventronics_LR-P-900-930-WW-XX-11 (9)
In: 2. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Välisvalgusti; 002_Tähis: OW2; 003_Osasüsteem: S252 Välisvalgustus; 205_IP_klass: IP67; 300_Paigaldusviis: seina; 305_Võimsus: 11.6 W; 900_Tootja: inventronics; 905_Mudel: Finesse
Name (inventronics_LR-P-900-930-WW-XX-11:inventronics_LR-P-900-930-WW-XX-11:...)
608876
616549
616557
616565
616573
616581
616589
616599
616607

# IfcLightFixture: meyer_Nanodot:meyer_Nanodot (32)
In: 1. KORRUS
Type - Material: <Unnamed>
Type - EL_Valgusti - 001_Nimetus: Välisvalgusti; 002_Tähis: H1; 003_Osasüsteem: S252 Välisvalgustus; 205_IP_klass: IP65; 300_Paigaldusviis: toru; 305_Võimsus: 1.5 W; 900_Tootja: Willy Meyer; 905_Mudel: Nanodot
Name (meyer_Nanodot:meyer_Nanodot:...)
701084
701307
701397
701398
701416
701417
701425
701426
701436
701437
701447
701448
701458
701459
701467
701468
701476
701477
701487
701488
701498
701499
701525
701526
701538
701539
701547
701548
701556
701557
701565
701566

# IfcSensor: ITKL_andur-pind:KA1, DALI, süvistatud (12)
Type - PredefinedType: USERDEFINED; Material: UHMW, White, Plastic, Opaque Black
Type - EL - 001_Nimetus: Kohalolekuandur; 002_Tähis: KA1; 900_Tootja: Osram; 905_Mudel: SENSOR LS/PD O CI
Name (ITKL_andur-pind:KA1, DALI, süvistatud:...) | In
509873 | 2. KORRUS
509995 | 2. KORRUS
510005 | 2. KORRUS
510053 | 2. KORRUS
510077 | 2. KORRUS
538419 | 1. KORRUS
538526 | 1. KORRUS
538646 | 1. KORRUS
538662 | 1. KORRUS
538812 | 1. KORRUS
538918 | 1. KORRUS
688314 | 1. KORRUS

# IfcSensor: ITKL_andur-pind:KA2, DALI, ribade vahel (32)
Type - PredefinedType: USERDEFINED; Material: UHMW, White, Plastic, Opaque Black
Type - EL - 001_Nimetus: Kohalolekuandur; 002_Tähis: KA2; 900_Tootja: Osram; 905_Mudel: Osram DALI LSPD LI G2
Name (ITKL_andur-pind:KA2, DALI, ribade vahel:...) | In
515574 | 2. KORRUS
515588 | 2. KORRUS
541232 | 1. KORRUS
541659 | 1. KORRUS
542073 | 1. KORRUS
542529 | 1. KORRUS
542545 | 1. KORRUS
542603 | 1. KORRUS
542613 | 1. KORRUS
542621 | 1. KORRUS
542635 | 1. KORRUS
542655 | 1. KORRUS
542693 | 1. KORRUS
542765 | 1. KORRUS
542806 | 1. KORRUS
648056 | 2. KORRUS
648101 | 2. KORRUS
648239 | 2. KORRUS
648257 | 2. KORRUS
648270 | 2. KORRUS
648281 | 2. KORRUS
648294 | 2. KORRUS
648305 | 2. KORRUS
648318 | 2. KORRUS
648329 | 2. KORRUS
648340 | 2. KORRUS
648351 | 2. KORRUS
648362 | 2. KORRUS
648377 | 2. KORRUS
648388 | 2. KORRUS
648399 | 2. KORRUS
648410 | 2. KORRUS

# IfcSensor: ITKL_andur-pind:KA3, DALI, pinnapealne (2)
In: 1. KORRUS
Type - PredefinedType: USERDEFINED; Material: UHMW, White, Plastic, Opaque Black
Type - EL - 001_Nimetus: Kohalolekuandur; 002_Tähis: KA3; 900_Tootja: Osram; 905_Mudel: SENSOR LS/PD O CI + QBM 220-240 LS/PD CM KIT
Name (ITKL_andur-pind:KA3, DALI, pinnapealne:...)
541214
541537

# IfcSensor: ITKL_andur-pind:KA4, on/off, pinnapealne, IP54 (3)
In: 1. KORRUS
Type - PredefinedType: USERDEFINED; Material: UHMW, White, Plastic, Opaque Black
Type - EL - 001_Nimetus: Kohalolekuandur; 002_Tähis: KA4; 900_Tootja: Steinel; 905_Mudel: PD-8 ECO COM1 - surface white
Name (ITKL_andur-pind:KA4, on/off, pinnapealne, IP54:...)
645846
646168
646291

# IfcSensor: ITKL_andur-pind:KA5, DALI, süvistatud IP54 (2)
In: 1. KORRUS
Type - PredefinedType: USERDEFINED; Material: UHMW, White, Plastic, Opaque Black
Type - EL - 001_Nimetus: Kohalolekuandur; 002_Tähis: KA5; 900_Tootja: Osram; 905_Mudel: SENSOR LS/PD O CI
Name (ITKL_andur-pind:KA5, DALI, süvistatud IP54:...)
538974
661732

# IfcSensor: ITKL_seade:ITKL_valgusandur, ITKL_seade:ITKL_valgusandur:725754
In: 1. KORRUS
Type - PredefinedType: LIGHTSENSOR; Material: <Unnamed>

# IfcSwitchingDevice: ITKL_1ne-imp-süvis:ITKL_1ne-imp-süvis (43)
Type - PredefinedType: USERDEFINED; Material: <Unnamed>, UHMW, White, Plastic, Opaque Black
Type - EL_Lüliti - 001_Nimetus: Impulsslüliti; 200_Paigaldus: Süvistatav; 205_IP_klass: IP20
Name (ITKL_1ne-imp-süvis:ITKL_1ne-imp-süvis:...) | In
498120 | 2. KORRUS
498339 | 2. KORRUS
498355 | 2. KORRUS
498728 | 2. KORRUS
498998 | 2. KORRUS
499271 | 2. KORRUS
499279 | 2. KORRUS
515342 | 2. KORRUS
515419 | 2. KORRUS
516966 | 2. KORRUS
517296 | 2. KORRUS
517670 | 2. KORRUS
517679 | 2. KORRUS
517690 | 2. KORRUS
517701 | 2. KORRUS
517716 | 2. KORRUS
517729 | 2. KORRUS
517740 | 2. KORRUS
517755 | 2. KORRUS
518258 | 2. KORRUS
518617 | 2. KORRUS
524688 | 1. KORRUS
524812 | 1. KORRUS
525264 | 1. KORRUS
525350 | 1. KORRUS
526641 | 1. KORRUS
528668 | 1. KORRUS
529232 | 1. KORRUS
529240 | 1. KORRUS
529868 | 1. KORRUS
531474 | 1. KORRUS
532044 | 1. KORRUS
532469 | 1. KORRUS
533096 | 1. KORRUS
540702 | 1. KORRUS
540882 | 1. KORRUS
540917 | 1. KORRUS
635323 | 2. KORRUS
641120 | 1. KORRUS
646551 | 1. KORRUS
646567 | 1. KORRUS
649701 | 2. KORRUS
649922 | 2. KORRUS

# IfcSwitchingDevice: ITKL_1ne-liht-pind:ITKL_1ne-liht-pind (3)
In: 2. KORRUS
Type - PredefinedType: USERDEFINED; Material: UHMW, White, Plastic, Opaque Black
Type - EL_Lüliti - 001_Nimetus: Lihtlüliti; 200_Paigaldus: Pinnapealne; 205_IP_klass: IP44
Name (ITKL_1ne-liht-pind:ITKL_1ne-liht-pind:...)
627538
627705
712875

# IfcSwitchingDevice: ITKL_1ne-liht-süvis:ITKL_1ne-liht-süvis (2)
In: 1. KORRUS
Type - PredefinedType: USERDEFINED; Material: <Unnamed>, UHMW, White, Plastic, Opaque Black
Type - EL_Lüliti - 001_Nimetus: Lihtlüliti; 200_Paigaldus: Süvistatav; 205_IP_klass: IP20
Name (ITKL_1ne-liht-süvis:ITKL_1ne-liht-süvis:...)
688390
688413

# IfcSwitchingDevice: ITKL_2ne-imp-süvis:ITKL_2ne-imp-süvis (38)
Type - PredefinedType: USERDEFINED; Material: UHMW, White, <Unnamed>, Plastic, Opaque Black
Type - EL_Lüliti - 001_Nimetus: Impulsslüliti; 200_Paigaldus: Süvistatav; 205_IP_klass: IP20
Name (ITKL_2ne-imp-süvis:ITKL_2ne-imp-süvis:...) | In
485447 | 2. KORRUS
485486 | 2. KORRUS
491641 | 2. KORRUS
491654 | 2. KORRUS
491667 | 2. KORRUS
491676 | 2. KORRUS
491685 | 2. KORRUS
491696 | 2. KORRUS
491707 | 2. KORRUS
497593 | 2. KORRUS
497629 | 2. KORRUS
497638 | 2. KORRUS
497647 | 2. KORRUS
497681 | 2. KORRUS
497706 | 2. KORRUS
497762 | 2. KORRUS
497945 | 2. KORRUS
498038 | 2. KORRUS
498059 | 2. KORRUS
498107 | 2. KORRUS
498129 | 2. KORRUS
498142 | 2. KORRUS
498183 | 2. KORRUS
515647 | 2. KORRUS
526549 | 1. KORRUS
526801 | 1. KORRUS
526983 | 1. KORRUS
527651 | 1. KORRUS
528220 | 1. KORRUS
529376 | 1. KORRUS
529986 | 1. KORRUS
530979 | 1. KORRUS
531051 | 1. KORRUS
531376 | 1. KORRUS
632292 | 2. KORRUS
634870 | 2. KORRUS
635520 | 2. KORRUS
641002 | 2. KORRUS
