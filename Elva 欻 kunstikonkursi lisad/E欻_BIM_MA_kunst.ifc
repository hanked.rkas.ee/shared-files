Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, SpaceBoundary2ndLevelAddOnView], Option [Drawing Scale: 100.000000], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: Off], Option [Split complex elements: On], Option [IFC Domain For Space Containment: Custom], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [Slabs with slanted edge(s): Extruded], Option [IFC Site Location: At Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Container Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: Visible Only], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: On], Option [IFC Space boundaries: On], Option [ARCHICAD Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: C:\Users\Dell\Documents\2_KUU\PÄÄSTE_ELVA\CAD\Elva_Pääste_3dymbrus.ifc
Time: 2021-09-08T12:15:12
Author: Kontakti Täisnimi
Organization: Building Designer Office
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD 24.0.0 INT FULL Windows version (IFC add-on version: 3008 INT FULL).
Authorization: Kontakti Täisnimi

# IfcProject, ELVA ÜHISHOONE
Phase: PÕHIPROJEKT

# IfcSite, RKAS Kinnistu Nimi -> SOLIBRI
Description: Kinnistu Kirjeldus; RefLatitude: 58, 14, 0, 900000; RefLongitude: 26, 25, 5, 100000; RefElevation: 0 mm; Classification: 1.0.1 IfcSite (kinnistu) (RKAS BIM + ARCHICAD Classification 24 + v 2.0)
AR_Kinnistu - 025_Max_kõrgus: 0 mm; 010_Katastritunnus: 17002:001:0035; 020_Pindala: 5119 m2; 015_Ehitatav_pindala: 1702.4 m2

# IfcBuilding, RKAS Hoone üldnimetus (kasutust iseloomustav) -> IFC Project Manager -> SOLIBRI
Classification: 1.0.2 IfcBuilding (hoone) (RKAS BIM + ARCHICAD Classification 24 + v 2.0)
AR_Hoone - 035_Sprinkler: no; 040_Kõrgus: 0 mm; ?: 0 m2; 050_Neto_pindala: 0 m2; 055_Neto_ruumala: 0 m3

# IfcBuildingStorey (4)
In: RKAS Hoone üldnimetus (kasutust iseloomustav) -> IFC Project Manager -> SOLIBRI
Classification: 1.0.3 IfcBuildingStorey (korrus) (RKAS BIM + ARCHICAD Classification 24 + v 2.0)
Name | Elevation (mm)
-2. Story | -3400
Vundament | -1700
Esimene korrus | 0
Katusekorrus | 7300

# IfcBuildingElementProxy: Air Space 200 (768)
In: Katusekorrus
Classification: 1311 Vaheseinad (Talo 2000 - ehitiseosade liigitus); 1.18 IfcWall (sein) (_RKAS BIM + ARCHICAD Classification); Material: Air Space
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: COLUMBIA KIVI (BETONEERITUD) 100, SS-05
In: Vundament
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.02 IfcBuildingElementProxyType (objekt) (RKAS BIM + ARCHICAD Classification); Material: COLUMBIA KIVI (BETONEERITUD)
Pset_BuildingElementProxyCommon - Reference: COLUMBIA KIVI (BETONEERITUD)
AR_001-002 - 001_Nimetus: SS-05; 002_Tüüp: COLUMBIA KIVI (BETONEERITUD)
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: COLUMBIA KIVI (BETONEERITUD) 200, PIIRDED JA TUGIMÜÜRID
In: Esimene korrus
Classification: 1311 Vaheseinad (Talo 2000 - ehitiseosade liigitus); 1.18 IfcWall (sein) (_RKAS BIM + ARCHICAD Classification); Material: COLUMBIA KIVI (BETONEERITUD)
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: IPE200 200 x 100 (2)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.02 IfcBuildingElementProxyType (objekt) (RKAS BIM + ARCHICAD Classification); Material: Teras S355
Pset_BuildingElementProxyCommon - Reference: IPE200
AR_001-002 - 001_Nimetus: TERASPIIRE; 002_Tüüp: IPE200
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: Olemasolevad Tarindid 100 x 100 (2)
In: Esimene korrus
Material: Olemasolevad Tarindid
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Olemasolevad Tarindid 40 x 60 (8)
In: Esimene korrus
Material: Olemasolevad Tarindid
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Olemasolevad Tarindid 500 x 500, SKULPTUUR
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.02 IfcBuildingElementProxyType (objekt) (RKAS BIM + ARCHICAD Classification); Material: Olemasolevad Tarindid
Pset_BuildingElementProxyCommon - Reference: Olemasolevad Tarindid
AR_001-002 - 001_Nimetus: SKULPTUUR; 002_Tüüp: Olemasolevad Tarindid
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Raudbetoon 1000, PK-01
In: Vundament
Classification: 1 Arhitektuur (sh sise- ja maastikuarhitektuur) (_RKAS BIM + ARCHICAD Classification); Material: Raudbetoon
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Raudbetoon 250, PK-01
In: Vundament
Classification: 1 Arhitektuur (sh sise- ja maastikuarhitektuur) (_RKAS BIM + ARCHICAD Classification); Material: Raudbetoon
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Tree Model Detailed 24 (4)
In: Esimene korrus
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcColumn: GENERIC - STRUCTURAL D102 (3)
In: -2. Story
Type - PredefinedType: COLUMN
Classification: 1.03 IfcColumnType (post) (RKAS BIM + ARCHICAD Classification); 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); Material: GENERIC - STRUCTURAL
Pset_ColumnCommon - Slope: 90 deg; IsExternal: yes
AR_001-002 - 001_Nimetus: LIPUVARDAD; 002_Tüüp: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFlowTerminal: Aluminium (12)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification); Material: Aluminium
AR_Valgusti - 001_Nimetus: VALGUSTID; 002_Tüüp: Aluminium; 400_Võimsus: 0; 405_Paigaldusviis: Undefined; 410_IP_klass: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Santehnika - 001_Nimetus: VALGUSTID; 002_Tüüp: Aluminium; 450_Paigaldus: Undefined; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowTerminal: GENERIC - PREFABRICATED (8)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification); Material: GENERIC - PREFABRICATED
AR_Valgusti - 001_Nimetus: VALGUSTID; 002_Tüüp: GENERIC - PREFABRICATED; 400_Võimsus: 0; 405_Paigaldusviis: Undefined; 410_IP_klass: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Santehnika - 001_Nimetus: VALGUSTID; 002_Tüüp: GENERIC - PREFABRICATED; 450_Paigaldus: Undefined; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: GENERIC - PREFABRICATED
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowTerminal: Olemasolevad Tarindid D320 (6)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification); Material: Olemasolevad Tarindid
AR_Valgusti - 001_Nimetus: VALGUSTID; 002_Tüüp: Olemasolevad Tarindid; 400_Võimsus: 0; 405_Paigaldusviis: Undefined; 410_IP_klass: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Santehnika - 001_Nimetus: VALGUSTID; 002_Tüüp: Olemasolevad Tarindid; 450_Paigaldus: Undefined; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: Olemasolevad Tarindid
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowTerminal: Olemasolevad Tarindid D76 (16)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification); Material: Olemasolevad Tarindid
AR_Valgusti - 001_Nimetus: VALGUSTID; 002_Tüüp: Olemasolevad Tarindid; 400_Võimsus: 0; 405_Paigaldusviis: Undefined; 410_IP_klass: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Santehnika - 001_Nimetus: VALGUSTID; 002_Tüüp: Olemasolevad Tarindid; 450_Paigaldus: Undefined; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: Olemasolevad Tarindid
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowTerminal: Steel 420 (2)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification); Material: Steel
AR_Valgusti - 001_Nimetus: VALGUSTID; 002_Tüüp: Steel; 400_Võimsus: 0; 405_Paigaldusviis: Undefined; 410_IP_klass: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Santehnika - 001_Nimetus: VALGUSTID; 002_Tüüp: Steel; 450_Paigaldus: Undefined; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: Steel
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: Steel 140 (38)
In: Esimene korrus
Material: Steel
AR_001-002 - 001_Nimetus: PARGIPINK; 002_Tüüp: Steel
Pset_QuantityTakeOff - Reference: Steel
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Classification
19 x PARGIPINK | 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification); 61 Sisustus ja mööbel (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005)
19 x PARGIPINK | 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)

# IfcFurnishingElement: ___SOLID3D___1EC76_BLOCK_ (4)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_001-002 - 002_Tüüp: ___SOLID3D___1EC76_BLOCK_
Pset_QuantityTakeOff - Reference: ___SOLID3D___1EC76_BLOCK_
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: ___SOLID3D___1EC77_BLOCK_ (4)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_001-002 - 002_Tüüp: ___SOLID3D___1EC77_BLOCK_
Pset_QuantityTakeOff - Reference: ___SOLID3D___1EC77_BLOCK_
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: ___SOLID3D___1EC78_BLOCK_ (4)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_001-002 - 002_Tüüp: ___SOLID3D___1EC78_BLOCK_
Pset_QuantityTakeOff - Reference: ___SOLID3D___1EC78_BLOCK_
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: ___SOLID3D___40_BLOCK_ (4)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_001-002 - 001_Nimetus: PRÜGIKAST; 002_Tüüp: ___SOLID3D___40_BLOCK_
Pset_QuantityTakeOff - Reference: ___SOLID3D___40_BLOCK_
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: ___SOLID3D___41_BLOCK_ (4)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_001-002 - 001_Nimetus: PRÜGIKAST; 002_Tüüp: ___SOLID3D___41_BLOCK_
Pset_QuantityTakeOff - Reference: ___SOLID3D___41_BLOCK_
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: ___SOLID3D___44_BLOCK_ (4)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_001-002 - 002_Tüüp: ___SOLID3D___44_BLOCK_
Pset_QuantityTakeOff - Reference: ___SOLID3D___44_BLOCK_
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: ___SOLID3D___45_BLOCK_ (4)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_001-002 - 002_Tüüp: ___SOLID3D___45_BLOCK_
Pset_QuantityTakeOff - Reference: ___SOLID3D___45_BLOCK_
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: ___SURFACE___42_BLOCK_ (4)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_001-002 - 001_Nimetus: PRÜGIKAST; 002_Tüüp: ___SURFACE___42_BLOCK_
Pset_QuantityTakeOff - Reference: ___SURFACE___42_BLOCK_
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: ___SURFACE___46_BLOCK_ (4)
In: Esimene korrus
Classification: 182 Hoone juurde kuuluv välisvarustus (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_001-002 - 001_Nimetus: PRÜGIKAST; 002_Tüüp: ___SURFACE___46_BLOCK_
Pset_QuantityTakeOff - Reference: ___SURFACE___46_BLOCK_
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: pargipink1 (2)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification); 61 Sisustus ja mööbel (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005)
AR_001-002 - 001_Nimetus: PARGIPINK; 002_Tüüp: pargipink1
Pset_QuantityTakeOff - Reference: pargipink1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcRailing: COLUMBIA KIVI (BETONEERITUD) (2)
In: Esimene korrus
Classification: 1.16 IfcRailingType (piire) (RKAS BIM + ARCHICAD Classification); 142 Tugimüürid ja piirded (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); Material: COLUMBIA KIVI (BETONEERITUD)
Pset_RailingCommon - Reference: COLUMBIA KIVI (BETONEERITUD); IsExternal: no
AR_001-002 - 001_Nimetus: SS-07; 002_Tüüp: COLUMBIA KIVI (BETONEERITUD)
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcRailing: COLUMBIA KIVI (BETONEERITUD) 200 (59)
In: Esimene korrus
Classification: 1.16 IfcRailingType (piire) (RKAS BIM + ARCHICAD Classification); 142 Tugimüürid ja piirded (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); Material: COLUMBIA KIVI (BETONEERITUD)
Pset_RailingCommon - Reference: COLUMBIA KIVI (BETONEERITUD); IsExternal: no
AR_001-002 - 001_Nimetus: PIIRDED JA TUGIMÜÜRID; 002_Tüüp: COLUMBIA KIVI (BETONEERITUD)
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcRailing: COLUMBIA KIVI (BETONEERITUD) 5 (54)
Classification: 1.16 IfcRailingType (piire) (RKAS BIM + ARCHICAD Classification); 181 Piirded (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); Material: COLUMBIA KIVI (BETONEERITUD)
Pset_RailingCommon - Reference: COLUMBIA KIVI (BETONEERITUD); IsExternal: no
AR_001-002 - 001_Nimetus: PIIRDED JA TUGIMÜÜRID; 002_Tüüp: COLUMBIA KIVI (BETONEERITUD)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
25 x PIIRDED JA TUGIMÜÜRID | -2. Story
29 x PIIRDED JA TUGIMÜÜRID | Esimene korrus

# IfcRailing: Foreground 287784464 10, PIIRDED JA TUGIMÜÜRID
In: Esimene korrus
Classification: 1.16 IfcRailingType (piire) (RKAS BIM + ARCHICAD Classification); 181 Piirded (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); Material: Foreground 287784464
Pset_RailingCommon - Reference: Foreground 287784464
AR_001-002 - 001_Nimetus: PIIRDED JA TUGIMÜÜRID; 002_Tüüp: Foreground 287784464
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcRailing: Foreground 287784464 5 (8)
In: Esimene korrus
Classification: 1.16 IfcRailingType (piire) (RKAS BIM + ARCHICAD Classification); 181 Piirded (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); Material: Foreground 287784464
Pset_RailingCommon - Reference: Foreground 287784464
AR_001-002 - 001_Nimetus: PIIRDED JA TUGIMÜÜRID; 002_Tüüp: Foreground 287784464
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcRailing: GENERIC - STRUCTURAL 100 x 100, VÄRAVAD
In: Esimene korrus
Classification: 1.16 IfcRailingType (piire) (RKAS BIM + ARCHICAD Classification); 181 Piirded (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); Material: GENERIC - STRUCTURAL
Pset_RailingCommon - Reference: GENERIC - STRUCTURAL
AR_001-002 - 001_Nimetus: VÄRAVAD; 002_Tüüp: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcRailing: GENERIC - STRUCTURAL 100 x 55, VÄRAVAD
In: Esimene korrus
Classification: 1.16 IfcRailingType (piire) (RKAS BIM + ARCHICAD Classification); 181 Piirded (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); Material: GENERIC - STRUCTURAL
Pset_RailingCommon - Reference: GENERIC - STRUCTURAL
AR_001-002 - 001_Nimetus: VÄRAVAD; 002_Tüüp: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcRailing: GENERIC - STRUCTURAL 21 x 60 (2)
In: Esimene korrus
Classification: 1.16 IfcRailingType (piire) (RKAS BIM + ARCHICAD Classification); 181 Piirded (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); Material: GENERIC - STRUCTURAL
Pset_RailingCommon - Reference: GENERIC - STRUCTURAL
AR_001-002 - 001_Nimetus: VÄRAVAD; 002_Tüüp: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcRailing: GENERIC - STRUCTURAL 40 x 60 (15)
In: Esimene korrus
Classification: 1.16 IfcRailingType (piire) (RKAS BIM + ARCHICAD Classification); 181 Piirded (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); Material: GENERIC - STRUCTURAL
Pset_RailingCommon - Reference: GENERIC - STRUCTURAL
AR_001-002 - 002_Tüüp: GENERIC - STRUCTURAL
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | 001_Nimetus
14 x VÄRAVAD | VÄRAVAD
BMR - 007 | BMR - 007

# IfcRailing: Olemasolevad Tarindid 100 x 100 (4)
In: Esimene korrus
Classification: 1.16 IfcRailingType (piire) (RKAS BIM + ARCHICAD Classification); 181 Piirded (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); Material: Olemasolevad Tarindid
Pset_RailingCommon - Reference: Olemasolevad Tarindid
AR_001-002 - 001_Nimetus: VÄRAVAD; 002_Tüüp: Olemasolevad Tarindid
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcRailing: Olemasolevad Tarindid 40 x 60 (10)
In: Esimene korrus
Classification: 1.16 IfcRailingType (piire) (RKAS BIM + ARCHICAD Classification); 181 Piirded (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); Material: Olemasolevad Tarindid
Pset_RailingCommon - Reference: Olemasolevad Tarindid
AR_001-002 - 001_Nimetus: VÄRAVAD; 002_Tüüp: Olemasolevad Tarindid
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcRailing: Olemasolevad Tarindid 60 x 60 (8)
In: Esimene korrus
Classification: 1.16 IfcRailingType (piire) (RKAS BIM + ARCHICAD Classification); 181 Piirded (V1- EHITUSKULUDE LIIGITAMINE EVS 885:2005); Material: Olemasolevad Tarindid
Pset_RailingCommon - Reference: Olemasolevad Tarindid
AR_001-002 - 001_Nimetus: VÄRAVAD; 002_Tüüp: Olemasolevad Tarindid
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
