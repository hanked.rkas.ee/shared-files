Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option [Drawing Scale: 100.000000], Option [Global Unique Identifiers (GUID): Keep existing], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Explode Composite and Complex Profile elements into parts: On], Option [Export geometries that Participates in Collision Detection only: Off], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [Slabs with slanted edge(s): Extruded], Option [Use legacy geometric methods as in Coordination View 1.0: Off], Option [IFC Site Geometry: As boundary representation (BRep)], Option [IFC Site Location: At Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Single Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: On], Option [IFC Space boundaries: Off], Option [ARCHICAD Zone Categories as IFC Space classification data: Off], Option [Element Classifications: Off]
File name: G:\Shared drives\Projektibüroo\Irina\Teaduse 2\Teaduse 2 Alice, Jane, Irina\EMAFAIL\ifc\AR_Teaduse2_PP_2019-12-17_AP_maa.ifc
Time: 2019-12-17T16:51:42
Author: Architect
Organization: Building Designer Office
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD-64 22.0.0 INT FULL Windows version (IFC add-on version: 6021 INT FULL).
Authorization: The authorising person

# IfcSite, Site
RefLatitude: 47, 33, 34, 948800; RefLongitude: 19, 3, 17, 204400; RefElevation: 0 mm

# IfcBuildingStorey, 1 KORRUS
In: Building
Elevation: 0 mm

# IfcBuildingElementProxy: Asfaltbetoon (4)
In: 1 KORRUS
Type - ElementType: Element type Asfaltbetoon
Material: MAAPIND
SEADMED - 02 Tähis: Asfaltbetoon
Name (MAAPIND; Objekti nimi:...) | Classification | Renovation Status
3 x  | 1.2 IfcBuildingElementProxy (objekt) (_RKAS BIM + ARCHICAD Classification); 172 Teede ja platside alused (EHITUSKULUDE LIIGITAMINE EVS 885:2005) | New
 | 1.2 IfcBuildingElementProxy (objekt) (_RKAS BIM + ARCHICAD Classification) | Existing

# IfcBuildingElementProxy: Maapind (6)
In: 1 KORRUS
Type - ElementType: Element type Maapind
Classification: 1.2 IfcBuildingElementProxy (objekt) (_RKAS BIM + ARCHICAD Classification); Material: MAAPIND
SEADMED - 02 Tähis: Maapind
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: TR - 004 (3)
In: 1 KORRUS
Type - ElementType: Element type TR - 004
Classification: 1.2 IfcBuildingElementProxy (objekt) (_RKAS BIM + ARCHICAD Classification); Material: MAAPIND
SEADMED - 02 Tähis: TR - 004
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: asfaltbetoon (2)
In: 1 KORRUS
Type - ElementType: Element type asfaltbetoon
Classification: 1.2 IfcBuildingElementProxy (objekt) (_RKAS BIM + ARCHICAD Classification); Material: MAAPIND
SEADMED - 02 Tähis: asfaltbetoon
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
