Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, SpaceBoundary2ndLevelAddOnView], Option [Elements to export: Filtered elements], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and Archicad 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: Off], Option [Split complex elements: On], Option [IFC Domain For Space Containment: Custom], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [IFC Model position: Survey Point and Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Container Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Geometry to type objects: Off], Option [Element Properties: Visible Only], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: On], Option [IFC Space boundaries: On], Option [Archicad Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: C:\Users\karle\Documents\KARLERK TARBE OÜ\Projektid\Ilmajaam\Ilmajaam TP\355_TP_SA_Paldiski-mnt-245-valgustid-20231115.ifc
Time: 2023-11-15T09:00:02
Author: Andres Rihe (allikirjastatud digitaalselt)
Organization: Building Designer Office
Written by: DDS_IFC v3.0
Made in: IFC file generated by Graphisoft Archicad 26.0.0 INT FULL Windows version (IFC add-on version: 4019 INT FULL).
Authorization: Andres Rihe (allikirjastatud digitaalselt)

# IfcProject, Ilmavaatlusjaama peahoone rekonstrueerimine
Description: Arhitektuur; Phase: Eelprojekt

# IfcSite, Paldiski mnt 245/1, Tallinn, Harjumaa
Description: Ühiskondlike ehitiste maa 100%; RefLatitude: 59, 26, 0, 0; RefLongitude: 24, 45, 0, 0; RefElevation: 0 mm; Classification: C Existing site/buildings/services (CAWS); 1.0.1 IfcSite (kinnistu) (RKAS BIM + ARCHICAD Classification 25 + v 2.0)
AR_Kinnistu - 010_Katastritunnus: 78406:605:0160; 020_Pindala: 24079 m2; 025_Max_kõrgus: 8600 mm; 015_Ehitatav_pindala: 1045.7 m2

# IfcBuilding, RKAS Hoone üldnimetus (kasutust iseloomustav) -> IFC Project Manager -> SOLIBRI
Classification: 1.0.2 IfcBuilding (hoone) (RKAS BIM + ARCHICAD Classification 25 + v 2.0)
AR_Hoone - 035_Sprinkler: no; 001_Nimetus: 12201 Büroohoone; 030_Hoone_aadress: Paldiski mnt 245/1 (katastriüksuse tunnus 78406:605:0160 ), Haabersti linnaosa, Tallinn, Eesti Vabariik; 040_Kõrgus: 8600 mm; ?: 1004.1 m2; 050_Neto_pindala: 1090.4 m2; 055_Neto_ruumala: 5563.9 m3

# IfcBuildingStorey (4)
In: RKAS Hoone üldnimetus (kasutust iseloomustav) -> IFC Project Manager -> SOLIBRI
Name | Elevation (mm) | Classification
Katusekorrus | 6240
Teine korrus | 3300 | 1.0.3 IfcBuildingStorey (korrus) (RKAS BIM + ARCHICAD Classification 25 + v 2.0)
Esimene korrus | 0 | 1.0.3 IfcBuildingStorey (korrus) (RKAS BIM + ARCHICAD Classification 25 + v 2.0)
Vundament | -1200 | 1.0.3 IfcBuildingStorey (korrus) (RKAS BIM + ARCHICAD Classification 25 + v 2.0)

# IfcBuildingElementProxy: Cube 26, REEPER
In: Esimene korrus
Classification: 1.02.1 IfcBuildingElementProxyType (reeper) (RKAS BIM + ARCHICAD Classification)
AR - 001_Nimetus: REEPER
Pset_BuildingElementProxyCommon - Reference: Cube 26
AR_Reeper - 01_X-(L-EST): 3000; 02_Y-(L-EST): 1000; 03_Z-(EH2000): 7000; 04_Nurk(◦): 0
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: SA- PM-1 plaatpõrand 4 (4)
In: Teine korrus
Classification: 1.14 IfcOpeningElement (avaelement) (RKAS BIM + ARCHICAD Classification); Material: SA- PM-1 plaatpõrand
AR - 001_Nimetus: Aknapale
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_BuildingElementProxyCommon - Reference: SA- PM-1 plaatpõrand

# IfcFlowTerminal: Ceiling Lamp 26 (6)
Classification: 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification)
AR_Santehnika - 002_Tähis: Ceiling Lamp 26; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Valgusti - 002_Tähis: Ceiling Lamp 26; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: Ceiling Lamp 26
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | AR_Santehnika, 001_Nimetus = AR_Valgusti, 001_Nimetus
4 x v0 | Teine korrus | v0
v13 | Teine korrus | v13
v10 | Esimene korrus | v10

# IfcFlowTerminal: Desk Lamp 04 26 (3)
In: Teine korrus
Classification: 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification)
AR_Santehnika - 001_Nimetus: v12; 002_Tähis: Desk Lamp 04 26; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Valgusti - 001_Nimetus: v12; 002_Tähis: Desk Lamp 04 26; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: Desk Lamp 04 26
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFlowTerminal: Fluorescent Lamp 26 (63)
Classification: 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 002_Tähis: Fluorescent Lamp 26; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: Fluorescent Lamp 26
AR_Santehnika - 002_Tähis: Fluorescent Lamp 26; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | AR_Valgusti, 001_Nimetus = AR_Santehnika, 001_Nimetus
v10 | Teine korrus | v10
32 x v6 | Teine korrus | v6
3 x v6a | Teine korrus | v6a
3 x v6b | Teine korrus | v6b
10 x v10 | Esimene korrus | v10
2 x v10a | Esimene korrus | v10a
2 x v4 | Esimene korrus | v4
10 x v6 | Esimene korrus | v6

# IfcFlowTerminal: Fluorescent Wall Lamp 26 (7)
In: Esimene korrus
Classification: 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification)
Pset_DistributionFlowElementCommon - Reference: Fluorescent Wall Lamp 26
AR_Valgusti - 001_Nimetus: v3; 002_Tähis: Fluorescent Wall Lamp 26; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Santehnika - 001_Nimetus: v3; 002_Tähis: Fluorescent Wall Lamp 26; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFlowTerminal: Lighting_Desk-Table-Lighting_Fritz-Hansen_KAISER-IdellT-6580-F (2)
In: Teine korrus
Classification: 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification)
AR_Santehnika - 001_Nimetus: v11; 002_Tähis: Lighting_Desk-Table-Lighting_Fritz-Hansen_KAISER-IdellT-6580-F; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Valgusti - 001_Nimetus: v11; 002_Tähis: Lighting_Desk-Table-Lighting_Fritz-Hansen_KAISER-IdellT-6580-F; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_DistributionFlowElementCommon - Reference: Lighting_Desk-Table-Lighting_Fritz-Hansen_KAISER-IdellT-6580-F

# IfcFlowTerminal: PL-1 10 x 60 (8)
In: Esimene korrus
Classification: 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification); Material: RAL 7033
AR_Valgusti - 001_Nimetus: v15; 002_Tähis: PL-1; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Santehnika - 001_Nimetus: v15; 002_Tähis: PL-1; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: PL-1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowTerminal: Pendant Lamp 26 (18)
Classification: 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 002_Tähis: Pendant Lamp 26; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: Pendant Lamp 26
AR_Santehnika - 002_Tähis: Pendant Lamp 26; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Name | In | AR_Valgusti, 001_Nimetus = AR_Santehnika, 001_Nimetus | Renovation Status
4 x v7 | Teine korrus | v7 | New
9 x v15 | Esimene korrus | v15 | Existing
5 x v7 | Esimene korrus | v7 | New

# IfcFlowTerminal: Recessed Spot 26 (79)
Classification: 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification)
AR_Santehnika - 002_Tähis: Recessed Spot 26; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: Recessed Spot 26
AR_Valgusti - 002_Tähis: Recessed Spot 26; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Name | In | AR_Santehnika, 001_Nimetus = AR_Valgusti, 001_Nimetus | Renovation Status
5 x v16 | Teine korrus | v16 | New
2 x v17 | Teine korrus | v17 | New
24 x v22 | Teine korrus | v22 | New
4 x v9 | Teine korrus | v9 | New
3 x v16 | Esimene korrus | v16 | New
16 x v19 | Esimene korrus | v19 | Existing
5 x v5 | Esimene korrus | v5 | Existing
9 x v5a | Esimene korrus | v5a | Existing
6 x v8 | Esimene korrus | v8 | New
5 x v9 | Esimene korrus | v9 | New

# IfcFlowTerminal: Spotlamp Ceiling 26 (35)
In: Esimene korrus
Classification: 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 002_Tähis: Spotlamp Ceiling 26; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Santehnika - 002_Tähis: Spotlamp Ceiling 26; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: Spotlamp Ceiling 26
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | AR_Valgusti, 001_Nimetus = AR_Santehnika, 001_Nimetus
33 x v15 | v15
2 x v21 | v21

# IfcFlowTerminal: Wall Lamp 26 (4)
In: Teine korrus
Classification: 1.12 IfcLightFixtureType (valgusti) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 001_Nimetus: v18; 002_Tähis: Wall Lamp 26; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Santehnika - 001_Nimetus: v18; 002_Tähis: Wall Lamp 26; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_DistributionFlowElementCommon - Reference: Wall Lamp 26

# IfcFurnishingElement: SA- Laminaat SM2(kollane laminaat) (5)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification); Material: SA- Laminaat SM2(kollane laminaat)
AR_Mööbel - 001_Nimetus: Laud; 002_Tähis: L123; 900_Tootja: Eritöö; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: L123
AC_Pset_RenovationAndPhasing - Renovation Status: New
