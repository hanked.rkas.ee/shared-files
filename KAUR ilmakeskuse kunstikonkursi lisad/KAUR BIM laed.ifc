Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, SpaceBoundary2ndLevelAddOnView], Option [Elements to export: Filtered elements], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and Archicad 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: Off], Option [Split complex elements: On], Option [IFC Domain For Space Containment: Custom], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [IFC Model position: Survey Point and Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Container Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Geometry to type objects: Off], Option [Element Properties: Visible Only], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: On], Option [IFC Space boundaries: On], Option [Archicad Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: C:\Users\karle\Documents\KARLERK TARBE OÜ\Projektid\Ilmajaam\Ilmajaam TP\355_TP_SA_Paldiski-mnt-245-laed-20231124.ifc
Time: 2023-11-24T18:08:53
Author: Andres Rihe (allikirjastatud digitaalselt)
Organization: Building Designer Office
Written by: DDS_IFC v3.0
Made in: IFC file generated by Graphisoft Archicad 26.0.0 INT FULL Windows version (IFC add-on version: 4019 INT FULL).
Authorization: Andres Rihe (allikirjastatud digitaalselt)

# IfcProject, Ilmavaatlusjaama peahoone rekonstrueerimine
Description: Arhitektuur; Phase: Eelprojekt

# IfcSite, Paldiski mnt 245/1, Tallinn, Harjumaa
Description: Ühiskondlike ehitiste maa 100%; RefLatitude: 59, 26, 0, 0; RefLongitude: 24, 45, 0, 0; RefElevation: 0 mm; Classification: C Existing site/buildings/services (CAWS); 1.0.1 IfcSite (kinnistu) (RKAS BIM + ARCHICAD Classification 25 + v 2.0)
AR_Kinnistu - 010_Katastritunnus: 78406:605:0160; 020_Pindala: 24079 m2; 025_Max_kõrgus: 8600 mm; 015_Ehitatav_pindala: 1045.7 m2

# IfcBuilding, RKAS Hoone üldnimetus (kasutust iseloomustav) -> IFC Project Manager -> SOLIBRI
Classification: 1.0.2 IfcBuilding (hoone) (RKAS BIM + ARCHICAD Classification 25 + v 2.0)
AR_Hoone - 035_Sprinkler: no; 001_Nimetus: 12201 Büroohoone; 030_Hoone_aadress: Paldiski mnt 245/1 (katastriüksuse tunnus 78406:605:0160 ), Haabersti linnaosa, Tallinn, Eesti Vabariik; 040_Kõrgus: 8600 mm; ?: 1004.1 m2; 050_Neto_pindala: 1090.4 m2; 055_Neto_ruumala: 5563.9 m3

# IfcBuildingStorey (4)
In: RKAS Hoone üldnimetus (kasutust iseloomustav) -> IFC Project Manager -> SOLIBRI
Name | Elevation (mm) | Classification
Katusekorrus | 6240
Teine korrus | 3300 | 1.0.3 IfcBuildingStorey (korrus) (RKAS BIM + ARCHICAD Classification 25 + v 2.0)
Esimene korrus | 0 | 1.0.3 IfcBuildingStorey (korrus) (RKAS BIM + ARCHICAD Classification 25 + v 2.0)
Vundament | -1200 | 1.0.3 IfcBuildingStorey (korrus) (RKAS BIM + ARCHICAD Classification 25 + v 2.0)

# IfcBuildingElementProxy: Cube 26, REEPER
In: Esimene korrus
Classification: 1.02.1 IfcBuildingElementProxyType (reeper) (RKAS BIM + ARCHICAD Classification)
Pset_BuildingElementProxyCommon - Reference: Cube 26
AR - 001_Nimetus: REEPER
AC_Pset_RenovationAndPhasing - Renovation Status: New
AR_Reeper - 01_X-(L-EST): 3000; 02_Y-(L-EST): 1000; 03_Z-(EH2000): 7000; 04_Nurk(◦): 0

# IfcCovering: Kipslae karkass 40 x 60 (30)
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: ET-05_Teras
Pset_CoveringCommon - Reference: RL-3; Material: Teras
AR - 001_Nimetus: Laekarkass
AC_Pset_RenovationAndPhasing - Renovation Status: New
AR_Viimistlus - 001_Nimetus: Laekarkass; 200_Materjal: Teras; 205_Tähis: RL-3; 215_Tulekindlusklass: A2-s1,d0; 220_Viimistlus: Tsingitud; 230_Niiskuskindel: yes; 235_Karkass: Puudub; 900_Tootja: Knauf; 905_Mudel: Knauf; 200_Materjal (MUDELIS): ET-05_Teras; 210_Paksus: 66 mm
Name | In
3 x RL-1 | Teine korrus
22 x RL-3 | Teine korrus
5 x RL-3 | Esimene korrus

# IfcCovering: Kipslae karkass Madal 70 x 27 (168)
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: ET-05_Teras
Pset_CoveringCommon - Reference: RL-4; Material: Teras
AR_Viimistlus - 200_Materjal: Teras; 205_Tähis: RL-4; 215_Tulekindlusklass: A2-s1,d0; 220_Viimistlus: Tsingitud; 230_Niiskuskindel: yes; 900_Tootja: Knauf; 905_Mudel: Knauf; 200_Materjal (MUDELIS): ET-05_Teras; 210_Paksus: 27 mm
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | AR_Viimistlus, 001_Nimetus = AR, 001_Nimetus | 235_Karkass
130 x RL-4 | Teine korrus | Laekarkass | Puudub
38 x RL-4 | Esimene korrus | Ripplae karkass | Undefined

# IfcCovering: Laudislae pruss 50 x 75 (10)
In: Esimene korrus
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: ET-06_Teras - Konstruktsioon
Pset_CoveringCommon - Reference: RL-2; Material: Puit
AR - 001_Nimetus: Laekarkass
AR_Viimistlus - 001_Nimetus: Laekarkass; 200_Materjal: Puit; 205_Tähis: RL-2; 215_Tulekindlusklass: Puudub; 220_Viimistlus: Hööveldatud; 230_Niiskuskindel: no; 235_Karkass: Puudub; 900_Tootja: Puit; 905_Mudel: Puit; 200_Materjal (MUDELIS): ET-06_Teras - Konstruktsioon; 210_Paksus: 75 mm
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcCovering: Ripplae L24 24 x 24 (58)
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: ET-05_Teras
Pset_CoveringCommon - Reference: RL-1; Material: Teras
AR_Viimistlus - 001_Nimetus: Ripplae liist; 200_Materjal: Teras; 205_Tähis: RL-1; 215_Tulekindlusklass: A2-s1,d0; 220_Viimistlus: NCS S2502-B; 230_Niiskuskindel: no; 235_Karkass: Undefined; 900_Tootja: Ecophon; 905_Mudel: T24, L24; 200_Materjal (MUDELIS): ET-05_Teras; 210_Paksus: 24 mm
AR - 001_Nimetus: Ripplae liist
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
8 x RL-1 | Teine korrus
50 x RL-1 | Esimene korrus

# IfcCovering: Ripplae T24 24 x 40 (137)
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: ET-05_Teras
Pset_CoveringCommon - Reference: RL-1; Material: Teras
AR_Viimistlus - 001_Nimetus: Ripplae liist; 200_Materjal: Teras; 205_Tähis: RL-1; 215_Tulekindlusklass: A2-s1,d0; 220_Viimistlus: NCS S2502-B; 230_Niiskuskindel: no; 235_Karkass: Undefined; 900_Tootja: Ecophon; 905_Mudel: T24, L24; 200_Materjal (MUDELIS): ET-05_Teras; 210_Paksus: 24 mm
AR - 001_Nimetus: Ripplae liist
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
61 x RL-1 | Teine korrus
76 x RL-1 | Esimene korrus

# IfcCovering: SA- Kipsplaat laes (3)
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: SA- Kipsplaat laes
Pset_CoveringCommon - Reference: L1; Material: Kiplsplaat
AR_Viimistlus - 001_Nimetus: Kipslagi; 200_Materjal: Kiplsplaat; 205_Tähis: L1; 215_Tulekindlusklass: A2-s1,do; 220_Viimistlus: värvitud maalrivalge, matt; 230_Niiskuskindel: no; 235_Karkass: Teraskarkass; 900_Tootja: Tikkurila, Knauf; 905_Mudel: Vivacolor Interior; 200_Materjal (MUDELIS): SA- Kipsplaat laes; 210_Paksus: 13 mm
AR - 001_Nimetus: Kipslagi
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
2 x L1 | Teine korrus
L1 | Esimene korrus

# IfcCovering: SA- Kipsplaat laes 13 (20)
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: SA- Kipsplaat laes
Pset_CoveringCommon - Reference: L1; Material: Kipsplaat; TotalThickness: 13 mm
AR_Viimistlus - 001_Nimetus: Kipslagi; 200_Materjal: Kipsplaat; 205_Tähis: L1; 215_Tulekindlusklass: A2-s1,d0; 220_Viimistlus: Värvitud, matt, maalrivalge, niiskuskindel; 230_Niiskuskindel: no; 235_Karkass: Teraskarkass/minimaalne; 900_Tootja: Tikkurila, Knauf; 905_Mudel: Vivakolor Interior; 200_Materjal (MUDELIS): SA- Kipsplaat laes; 210_Paksus: 13 mm
AR - 001_Nimetus: Kipslagi
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | 225_Pindala (m2)
L1 | Teine korrus | 32.9522
L1 | Teine korrus | 15.5922
L1 | Teine korrus | 15.9174
L1 | Teine korrus | 33.5244
L1 | Teine korrus | 23.1797
L1 | Teine korrus | 3.14283
L1 | Teine korrus | 7.32697
L1 | Teine korrus | 24.9114
L1 | Teine korrus | 3.12614
L1 | Teine korrus | 23.3279
L1 | Teine korrus | 23.0527
L1 | Teine korrus | 23.3464
L1 | Teine korrus | 6.20609
L1 | Teine korrus | 21.5877
L1 | Esimene korrus | 11.9699
L1 | Esimene korrus | 12.326
L1 | Esimene korrus | 1.76756
L1 | Esimene korrus | 12.2796
L1 | Esimene korrus | 10.4211
L1 | Esimene korrus | 12.5672

# IfcCovering: SA- Kipsplaat laes 40, L1
In: Esimene korrus
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: SA- Kipsplaat laes
Pset_CoveringCommon - Reference: L1; Material: Kipsplaat; TotalThickness: 40 mm
AR_Viimistlus - 001_Nimetus: Kipslagi; 200_Materjal: Kipsplaat; 205_Tähis: L1; 215_Tulekindlusklass: A2-s1,d0; 220_Viimistlus: Värvitud, matt, maalrivalge, niiskuskindel; 230_Niiskuskindel: no; 235_Karkass: Teraskarkass/minimaalne; 900_Tootja: Tikkurila, Knauf; 905_Mudel: Vivakolor Interior; 200_Materjal (MUDELIS): SA- Kipsplaat laes; 225_Pindala: 6.45011 m2; 210_Paksus: 13 mm
AR - 001_Nimetus: Kipslagi
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcCovering: SA- Kipsplaat laes 5, PM-8
In: Esimene korrus
Type - PredefinedType: FLOORING
Classification: 1.06 IfcCoveringType.FLOORING (põrandakatted) (RKAS BIM + ARCHICAD Classification); Material: SA- Kipsplaat laes
Pset_CoveringCommon - Reference: SA- Kipsplaat laes; TotalThickness: 5 mm
AR_Viimistlus - 001_Nimetus: EPO lakk; 900_Tootja: EPO Proff; 905_Mudel: Mattlakk R10 klaaskuuliga, veebaasil; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined; 200_Materjal (MUDELIS): SA- Kipsplaat laes
AC_Pset_RenovationAndPhasing - Renovation Status: New
AR - 001_Nimetus: EPO lakk

# IfcCovering: SA- L5 värvitud lagi (38)
In: Esimene korrus
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: SA- L5 värvitud lagi
AR_Viimistlus - 001_Nimetus: Laevärv; 200_Materjal: Veepõhine värv; 205_Tähis: L5; 215_Tulekindlusklass: B-s1,d0; 220_Viimistlus: Matt, RAL7044; 230_Niiskuskindel: yes; 235_Karkass: Puudub; 900_Tootja: Tikkurila; 905_Mudel: Vivacolor Interior; 200_Materjal (MUDELIS): SA- L5 värvitud lagi; 210_Paksus: 1 mm
AR - 001_Nimetus: Laevärv
Pset_CoveringCommon - Reference: L5; Material: Veepõhine värv
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcCovering: SA- L5 värvitud lagi 5 (15)
In: Esimene korrus
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: SA- L5 värvitud lagi
AR_Viimistlus - 001_Nimetus: Laevärv; 200_Materjal: Veepõhine värv; 205_Tähis: L5; 215_Tulekindlusklass: B-s1,d0; 220_Viimistlus: Värvitud, matt, RAL7044 (soe kesmise tumedusega hall); 230_Niiskuskindel: yes; 235_Karkass: Puudub; 900_Tootja: Tikkurila; 905_Mudel: Vivakolor Interior; 200_Materjal (MUDELIS): SA- L5 värvitud lagi; 210_Paksus: 1 mm
Pset_CoveringCommon - Reference: L5; Material: Veepõhine värv; TotalThickness: 5 mm
AR - 001_Nimetus: Laevärv
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 225_Pindala (m2)
L5 | 69.4405
L5 | 15.608
L5 | 2.19785
L5 | 12.2933
L5 | 3.89205
L5 | 34.7202
L5 | 1.53
L5 | 1.40621
L5 | 33.8763
L5 | 0.558964
L5 | 2.45614
L5 | 2.14674
L5 | 15.563
L5 | 3.42482
L5 | 33.7367

# IfcCovering: SA- Laudlagi 15 (2)
In: Esimene korrus
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: SA- Laudlagi
Pset_CoveringCommon - Reference: L2; Material: Puit; TotalThickness: 15 mm
AR_Viimistlus - 001_Nimetus: Laudis lagi; 200_Materjal: Puit; 205_Tähis: L2; 215_Tulekindlusklass: Puudub; 220_Viimistlus: Termotöödeldud; 230_Niiskuskindel: no; 235_Karkass: Puitkarkass/kertopuu; 900_Tootja: Puumarket; 905_Mudel: 15×120, Haab Profiil STS4, termotöödeldud; 200_Materjal (MUDELIS): SA- Laudlagi; 210_Paksus: 15 mm
AR - 001_Nimetus: Laudis lagi
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 225_Pindala (m2)
L2 | 4.89433
L2 | 8.83964

# IfcCovering: SA- Puitkiud ripplagi 24 (10)
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: SA- Puitkiud ripplagi
AR_Viimistlus - 001_Nimetus: Ripplagi; 200_Materjal: Puitkiud; 205_Tähis: L4; 215_Tulekindlusklass: A2-s1, d0; 220_Viimistlus: toon: Hall; 230_Niiskuskindel: yes; 235_Karkass: Teraskarkass T24, L24, hall; 900_Tootja: Cewood; 905_Mudel: Cewood servatüüp POG-T24, laastu laius 1,5mm; 200_Materjal (MUDELIS): SA- Puitkiud ripplagi; 210_Paksus: 24 mm
Pset_CoveringCommon - Reference: L4; Material: Puitkiud; TotalThickness: 24 mm
AR - 001_Nimetus: Ripplagi
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | 225_Pindala (m2)
L4 | Teine korrus | 17.3807
L4 | Teine korrus | 41.9708
L4 | Esimene korrus | 6.38823
L4 | Esimene korrus | 0.910279
L4 | Esimene korrus | 3.766
L4 | Esimene korrus | 21.48
L4 | Esimene korrus | 3.37825
L4 | Esimene korrus | 6.38678
L4 | Esimene korrus | 0.898044
L4 | Esimene korrus | 7.72647

# IfcCovering: SA- Puitkiudlagi 25 (157)
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: SA- Puitkiudlagi
Pset_CoveringCommon - Material: Puitkiud; TotalThickness: 25 mm
AR - 001_Nimetus: Akustiline plaat
AR_Viimistlus - 001_Nimetus: Akustiline plaat; 200_Materjal: Puitkiud; 215_Tulekindlusklass: A2-s1, d0; 230_Niiskuskindel: yes; 235_Karkass: Puudub, kruvikinnitus; 900_Tootja: Cewood; 200_Materjal (MUDELIS): SA- Puitkiudlagi; 210_Paksus: 25 mm
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | Reference = 205_Tähis | 220_Viimistlus | 905_Mudel | 225_Pindala (m2)
102 x L3 | Teine korrus | L3 | Toon: Hall | P0, laastu laius 1,5mm. Mooduli mõõt 1200x600x25 | 0.72
22 x L7 | Teine korrus | L7 | toon: Hall | P0, laastu laius 1,5mm. Mooduli mõõt 2400x600x25 | 1.44
5 x L3 | Esimene korrus | L3 | Toon: Hall | P0, laastu laius 1,5mm. Mooduli mõõt 1200x600x25 | 0.72
28 x L7 | Esimene korrus | L7 | toon: Hall | P0, laastu laius 1,5mm. Mooduli mõõt 2400x600x25 | 1.44

# IfcCovering: SA- mineraal ripplagi 24 (3)
In: Esimene korrus
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: SA- mineraal ripplagi
Pset_CoveringCommon - Reference: L6; Material: Mineraalkiud; TotalThickness: 24 mm
AR_Viimistlus - 001_Nimetus: Ripplagi; 200_Materjal: Mineraalkiud; 205_Tähis: L6; 215_Tulekindlusklass: A2-s1,d0; 220_Viimistlus: Valge; 230_Niiskuskindel: yes; 235_Karkass: Ripplae karkass T24, L24, valge; 900_Tootja: Ecophon; 905_Mudel: Advantage A: karkass T24 600x600 mm; 200_Materjal (MUDELIS): SA- mineraal ripplagi; 210_Paksus: 20 mm
AR - 001_Nimetus: Ripplagi
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 225_Pindala (m2)
L6 | 9.67431
L6 | 6.19685
L6 | 13.0378

# IfcCovering: SA- mineraal ripplagi 25, L3
In: Teine korrus
Type - PredefinedType: CEILING
Classification: 1.04 IfcCoveringType.CEILING (ripplagi) (RKAS BIM + ARCHICAD Classification); Material: SA- mineraal ripplagi
Pset_CoveringCommon - Reference: SA- mineraal ripplagi; Material: SA- mineraal ripplagi; TotalThickness: 25 mm
AR - 001_Nimetus: L3
AR_Viimistlus - 001_Nimetus: L3; 200_Materjal: SA- mineraal ripplagi; 205_Tähis: SA- mineraal ripplagi; 215_Tulekindlusklass: A2-s1, d0; 220_Viimistlus: Toon: Hall; 230_Niiskuskindel: yes; 235_Karkass: Puudub, kruvikinnitus; 900_Tootja: Cewood; 905_Mudel: P0, laastu laius 1,5mm. Mooduli mõõt 1200x600x25; 200_Materjal (MUDELIS): SA- mineraal ripplagi; 225_Pindala: 0.72 m2; 210_Paksus: 25 mm
AC_Pset_RenovationAndPhasing - Renovation Status: New
