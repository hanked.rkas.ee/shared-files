Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, SpaceBoundary2ndLevelAddOnView], Option [Elements to export: Filtered elements], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and Archicad 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: Off], Option [Split complex elements: On], Option [IFC Domain For Space Containment: Custom], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [IFC Model position: Survey Point and Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Container Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Geometry to type objects: Off], Option [Element Properties: Visible Only], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: On], Option [IFC Space boundaries: On], Option [Archicad Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: C:\Users\karle\Documents\KARLERK TARBE OÜ\Projektid\Ilmajaam\Ilmajaam TP\355_TP_SA_Paldiski-mnt-245-mööbel-santehnika-20231115.ifc
Time: 2023-11-15T10:33:15
Author: Andres Rihe (allikirjastatud digitaalselt)
Organization: Building Designer Office
Written by: DDS_IFC v3.0
Made in: IFC file generated by Graphisoft Archicad 26.0.0 INT FULL Windows version (IFC add-on version: 4019 INT FULL).
Authorization: Andres Rihe (allikirjastatud digitaalselt)

# IfcProject, Ilmavaatlusjaama peahoone rekonstrueerimine
Description: Arhitektuur; Phase: Eelprojekt

# IfcSite, Paldiski mnt 245/1, Tallinn, Harjumaa
Description: Ühiskondlike ehitiste maa 100%; RefLatitude: 59, 26, 0, 0; RefLongitude: 24, 45, 0, 0; RefElevation: 0 mm; Classification: 1.0.1 IfcSite (kinnistu) (RKAS BIM + ARCHICAD Classification 25 + v 2.0); C Existing site/buildings/services (CAWS)
AR_Kinnistu - 010_Katastritunnus: 78406:605:0160; 020_Pindala: 24079 m2; 025_Max_kõrgus: 8600 mm; 015_Ehitatav_pindala: 1045.7 m2

# IfcBuilding, RKAS Hoone üldnimetus (kasutust iseloomustav) -> IFC Project Manager -> SOLIBRI
Classification: 1.0.2 IfcBuilding (hoone) (RKAS BIM + ARCHICAD Classification 25 + v 2.0)
AR_Hoone - 035_Sprinkler: no; 001_Nimetus: 12201 Büroohoone; 030_Hoone_aadress: Paldiski mnt 245/1 (katastriüksuse tunnus 78406:605:0160 ), Haabersti linnaosa, Tallinn, Eesti Vabariik; 040_Kõrgus: 8600 mm; ?: 1004.1 m2; 050_Neto_pindala: 1090.4 m2; 055_Neto_ruumala: 5563.9 m3

# IfcBuildingStorey (4)
In: RKAS Hoone üldnimetus (kasutust iseloomustav) -> IFC Project Manager -> SOLIBRI
Name | Elevation (mm) | Classification
Katusekorrus | 6240
Teine korrus | 3300 | 1.0.3 IfcBuildingStorey (korrus) (RKAS BIM + ARCHICAD Classification 25 + v 2.0)
Esimene korrus | 0 | 1.0.3 IfcBuildingStorey (korrus) (RKAS BIM + ARCHICAD Classification 25 + v 2.0)
Vundament | -1200 | 1.0.3 IfcBuildingStorey (korrus) (RKAS BIM + ARCHICAD Classification 25 + v 2.0)

# IfcBuildingElementProxy: Cube 26, REEPER
In: Esimene korrus
Classification: 1.02.1 IfcBuildingElementProxyType (reeper) (RKAS BIM + ARCHICAD Classification)
Pset_BuildingElementProxyCommon - Reference: Cube 26
AR - 001_Nimetus: REEPER
AR_Reeper - 01_X-(L-EST): 3000; 02_Y-(L-EST): 1000; 03_Z-(EH2000): 7000; 04_Nurk(◦): 0
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcBuildingElementProxy: DURAVIT_234880-DuraSquare-sink(1) (4)
Classification: 1.02 IfcBuildingElementProxyType (objekt) (RKAS BIM + ARCHICAD Classification)
Pset_BuildingElementProxyCommon - Reference: W3, W4
AR - 001_Nimetus: Valamu, segisti
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
2 x W3, W4 | Teine korrus
2 x W3, W4 | Esimene korrus

# IfcBuildingElementProxy: SA- PM-1 plaatpõrand 20 (2)
In: Teine korrus
Classification: 1.14 IfcOpeningElement (avaelement) (RKAS BIM + ARCHICAD Classification); Material: SA- PM-1 plaatpõrand
Pset_BuildingElementProxyCommon - Reference: SA- PM-1 plaatpõrand
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | 001_Nimetus
Aknapale | Aknapale
PM-4 | PM-4

# IfcBuildingElementProxy: WC 26 (7)
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
3 x W1, W2 | Teine korrus
4 x W1, W2 | Esimene korrus

# IfcBuildingElementProxy: katrin_bin_25_litre_steel (2)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcCovering: KON-00_GENEERILINE - KONSTRUKTSIOON 20 (2)
In: Teine korrus
Type - PredefinedType: CLADDING
Classification: 1.05 IfcCoveringType.CLADDING (seina viimistlus) (RKAS BIM + ARCHICAD Classification); Material: KON-00_GENEERILINE - KONSTRUKTSIOON
Pset_CoveringCommon - Reference: KON-00; TotalThickness: 20 mm
AR_Viimistlus - 001_Nimetus: SM-2; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined; 200_Materjal (MUDELIS): KON-00_GENEERILINE - KONSTRUKTSIOON
AR - 001_Nimetus: SM-2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFlowTerminal: Basin 26 (4)
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Santehnika - 915_Kasutus-ja_hooldusjuhend: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | AR_Valgusti, 001_Nimetus = AR_Santehnika, 001_Nimetus | AR_Valgusti, 002_Tähis = Reference = AR_Santehnika, 002_Tähis | AR_Valgusti, 900_Tootja = AR_Santehnika, 900_Tootja | AR_Valgusti, 905_Mudel = AR_Santehnika, 905_Mudel | AR_Valgusti, 910_Tooteinfo = AR_Santehnika, 910_Tooteinfo | 455_Eriomadused
W36, W4 | Teine korrus | Valamu, segisti | W36, W4 | Laufen, Gustavsberg | PRO S 810962, GB41216047 | https://www.sansan.ee/valamud/vannitoavalamud/vannitoavalamu-laufen-pro-s-810962.html , https://www.gustavsberg.com/ee/tooted/segistid/valamusegistid/product/gb41216047/valamusegisti-new-nautic-energiaklass-a | Undefined
W27 | Esimene korrus | Valamu | W27 | Gustavsberg | GB157119630110 | https://www.gustavsberg.com/ee/otsi?tx_solr%5Bq%5D=7119-63 | Invavalamu
W36, W4 | Esimene korrus | Valamu, segisti | W36, W4 | Laufen, Gustavsberg | PRO S 810962, GB41216047 | https://www.sansan.ee/valamud/vannitoavalamud/vannitoavalamu-laufen-pro-s-810962.html , https://www.gustavsberg.com/ee/tooted/segistid/valamusegistid/product/gb41216047/valamusegisti-new-nautic-energiaklass-a | Undefined
W9, W4 | Esimene korrus | Valamu, segisti | W9, W4 | Laufen, Gustavsberg | PRO S 815961, GB41216047 | https://www.sansan.ee/valamud/vannitoavalamud/vannitoavalamu-laufen-pro-s-815961.html , https://www.gustavsberg.com/ee/tooted/segistid/valamusegistid/product/gb41216047/valamusegisti-new-nautic-energiaklass-a | Undefined

# IfcFlowTerminal: Disposal Bin (7)
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 002_Tähis: W17; 900_Tootja: Brabantia; 905_Mudel: NewIcon 115561; 910_Tooteinfo: https://www.brabantia.com/uk/newicon-wall-mounted-bin-3-litre-plastic-inner-bucket-matt-steel/; 915_Kasutus-ja_hooldusjuhend: https://www.brabantia.com/uk/newicon-wall-mounted-bin-3-litre-plastic-inner-bucket-matt-steel/
AR_Santehnika - 002_Tähis: W17; 455_Eriomadused: Undefined; 900_Tootja: Brabantia; 905_Mudel: NewIcon 115561; 910_Tooteinfo: https://www.brabantia.com/uk/newicon-wall-mounted-bin-3-litre-plastic-inner-bucket-matt-steel/; 915_Kasutus-ja_hooldusjuhend: https://www.brabantia.com/uk/newicon-wall-mounted-bin-3-litre-plastic-inner-bucket-matt-steel/
Pset_DistributionFlowElementCommon - Reference: W17
Name | In | AR_Valgusti, 001_Nimetus = AR_Santehnika, 001_Nimetus | Renovation Status
2 x W17 | Teine korrus | Prügikast | New
W17 | Teine korrus | W17 | Existing
4 x W17 | Esimene korrus | Prügikast | New

# IfcFlowTerminal: Radiator Horizontal Bars 26 (4)
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 001_Nimetus: Radiaator; 002_Tähis: W31; 900_Tootja: Brisk; 905_Mudel: 000000000501726906; 910_Tooteinfo: https://www.k-rauta.ee/p/elektriline-kateratikukuivati-brisk-kroom-550-mm-x-550-mm/351d; 915_Kasutus-ja_hooldusjuhend: https://www.k-rauta.ee/p/elektriline-kateratikukuivati-brisk-kroom-550-mm-x-550-mm/351d
Pset_DistributionFlowElementCommon - Reference: W31
AC_Pset_RenovationAndPhasing - Renovation Status: New
AR_Santehnika - 001_Nimetus: Radiaator; 002_Tähis: W31; 455_Eriomadused: Undefined; 900_Tootja: Brisk; 905_Mudel: 000000000501726906; 910_Tooteinfo: https://www.k-rauta.ee/p/elektriline-kateratikukuivati-brisk-kroom-550-mm-x-550-mm/351d; 915_Kasutus-ja_hooldusjuhend: https://www.k-rauta.ee/p/elektriline-kateratikukuivati-brisk-kroom-550-mm-x-550-mm/351d
Name | In
2 x W31 | Teine korrus
2 x W31 | Esimene korrus

# IfcFlowTerminal: Sanitary_Accessories_DELABIE_4043BK-Matte-black-stainless-steel-coat (20)
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Santehnika - 001_Nimetus: Nagi; 002_Tähis: W13; 455_Eriomadused: Undefined; 900_Tootja: Haceka; 905_Mudel: Kosmos 1208731; 910_Tooteinfo: https://www.haceka.com/products/kosmos-hook-single-8718848204055?fbclid=IwAR285Fl7ChVNgWl-tmSZRDc-uXlqi58WlBm41Ovd5nv3scVDqCeiExJt8pY
AR_Valgusti - 001_Nimetus: Nagi; 002_Tähis: W13; 900_Tootja: Haceka; 905_Mudel: Kosmos 1208731; 910_Tooteinfo: https://www.haceka.com/products/kosmos-hook-single-8718848204055?fbclid=IwAR285Fl7ChVNgWl-tmSZRDc-uXlqi58WlBm41Ovd5nv3scVDqCeiExJt8pY
Pset_DistributionFlowElementCommon - Reference: W13
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
6 x W13 | Teine korrus
14 x W13 | Esimene korrus

# IfcFlowTerminal: Sanitary_Dispensers_Mediclinics_Liquid-soap-dispenser-Lever-DJP0034x(1) (13)
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 002_Tähis: W24; 900_Tootja: Madiclinics; 905_Mudel: DJ0040B must; 910_Tooteinfo: https://www.mediclinics.com/en/soap-dispenser/1689-push-button-soap-dispensers-DJ0040B.html; 915_Kasutus-ja_hooldusjuhend: https://www.mediclinics.com/en/soap-dispenser/1689-push-button-soap-dispensers-DJ0040B.html
AR_Santehnika - 002_Tähis: W24; 455_Eriomadused: Undefined; 900_Tootja: Madiclinics; 905_Mudel: DJ0040B must; 910_Tooteinfo: https://www.mediclinics.com/en/soap-dispenser/1689-push-button-soap-dispensers-DJ0040B.html; 915_Kasutus-ja_hooldusjuhend: https://www.mediclinics.com/en/soap-dispenser/1689-push-button-soap-dispensers-DJ0040B.html
Pset_DistributionFlowElementCommon - Reference: W24
Pset_ManufacturerTypeInformation - Manufacturer: Mediclinics
Pset_ManufacturerOccurrence - SerialNumber: DJP0034C
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | AR_Valgusti, 001_Nimetus = AR_Santehnika, 001_Nimetus
2 x W14 | Teine korrus | Dosaator
4 x W14 | Teine korrus | W14
7 x W14 | Esimene korrus | Dosaator

# IfcFlowTerminal: Sanitary_Mirrors_HEWI_adjustable-mirror-w-lever_801-01-100, W24
In: Esimene korrus
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 001_Nimetus: Peegel; 002_Tähis: W24; 900_Tootja: Delabie; 905_Mudel: DE-510201N; 910_Tooteinfo: https://www.pegu.ee/et/a/delabie-be-line-inva-peegel-reguleeritav-600x500-pikk-erconomic-kaepide; 915_Kasutus-ja_hooldusjuhend: Undefined; sets with these values: 2
Pset_DistributionFlowElementCommon - Reference: W24
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFlowTerminal: Sanitary_Mirrors_Ideagroup_ASOLA-mirror_ITA (5)
Classification: 1.02 IfcBuildingElementProxyType (objekt) (RKAS BIM + ARCHICAD Classification)
AR - 001_Nimetus: Mööbel; 002_Tähis: Sanitary_Mirrors_Ideagroup_ASOLA-mirror
AR_300-396 - 300_Tähis: Sanitary_Mirrors_Ideagroup_ASOLA-mirror: 80x900; 305_Ava_mõõt: 80x900; 308_Ruumi number: New Option; 310_Materjal: Undefined; 315_Avanemine (Avanemise kirjeldus): Undefined; 315_Avanemine: Undefined; 320_Klaas: Undefined; 325_Helipidavus: Undefined; 330_Tulekindlus: Undefined; 332_Turvaklass: Undefined; 333_Suitsueemaldus: Undefined; 335_Välispiire: no; 341_Soojusläbivus (raam, avatäide vms): 0; 350_Klaaspakett: Undefined; 360_Ratastooliga: no; 365_Isesulguv: no; 370_Evakuatsiooniväljapääs: True; 371_Evakuatsioonisulused/inimeste arv: 0.00; 372_Kaardilugeja: New Option; 378_Lävepakk: Undefined; 379_Käepide: Undefined; 380_Lukustus: Undefined; 381_Lukuraam: Undefined; 382_Südamik: Undefined; 383_Vasturaud: Undefined; 384_Sulgur: Undefined; 395_Veeplekk: Undefined; 396_Aknalaud: Undefined
AR_500-550 - 500_Kandev: no
AR_Ruum - 110_Tüüp: Undefined; 125_Turvatsoon: Undefined
AR_900-915 - 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Hoone - 035_Sprinkler: no
AR_Kinnistu - 010_Katastritunnus: RKAS Katastritunnus -> IFC Project Manager
AR_Korrus - 060_Korruse_nimi: Undefined; 065_Korruse_number: Undefined; 070_Maapealne: no
AR_400-455 - 455_Eriomadused: Undefined; 400_Võimsus: 0; 405_Paigaldusviis: Undefined; 410_IP_klass: Undefined; 450_Paigaldus: Undefined
AR_Tsoon - 080_Tähis: Undefined; 085_Tuletõkkesektsioon: Undefined
AR_001-002 - 001_Nimetus: Mööbel; 002_Tüüp: Sanitary_Mirrors_Ideagroup_ASOLA-mirror
PRODUCT DESCRIPTION (Expression) - Product location: Name of project: Ilmavaatlusjaama peahoone rekonstrueerimineSite: RKAS Kinnistu Nimi -> SOLIBRI Story: Teine korrus Room:; Hotlinked Door Context ID: Mööbel; Stair Subelements - Numerical IDs: Mööbel
AR_200-245 - 205_Tüüp: Sanitary_Mirrors_Ideagroup_ASOLA-mirror; 215_Tulekindlusklass: Undefined; 220_Viimistlus: Undefined; 230_Niiskuskindel: no; 235_Karkass: Undefined; 240_Märghõõrdekindlus: Undefined; 245_Aluspind: Undefined; 206_Tüüp: Mööbel
MANUFACTURING - Product Website: www.graphisoft.com
AR_Santehnika - 001_Nimetus: Peegel; 002_Tähis: W11; 455_Eriomadused: Undefined; 900_Tootja: Andresglass; 905_Mudel: Elli; 910_Tooteinfo: https://klaasistuudio.ee/elli.html; 915_Kasutus-ja_hooldusjuhend: https://klaasistuudio.ee/elli.html
AR_Valgusti - 001_Nimetus: Peegel; 002_Tähis: W11; 900_Tootja: Andresglass; 905_Mudel: Elli; 910_Tooteinfo: https://klaasistuudio.ee/elli.html; 915_Kasutus-ja_hooldusjuhend: https://klaasistuudio.ee/elli.html
Pset_DistributionFlowElementCommon - Reference: W11
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
3 x Mööbel | Teine korrus
2 x Mööbel | Esimene korrus

# IfcFlowTerminal: Sanitary_Toilet-Accessories_DELABIE_4051MW-Be-LineR-wall-mounted-toilet-brus (7)
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 001_Nimetus: Tualettpoti hari; 002_Tähis: W19; 900_Tootja: Haceka; 905_Mudel: Kosmos-1208529 must; 910_Tooteinfo: https://www.haceka.com/products/kosmos-toiletbrush-metal-8718848202037; 915_Kasutus-ja_hooldusjuhend: https://www.haceka.com/products/kosmos-toiletbrush-metal-8718848202037
AR_Santehnika - 001_Nimetus: Tualettpoti hari; 002_Tähis: W19; 455_Eriomadused: Undefined; 900_Tootja: Haceka; 905_Mudel: Kosmos-1208529 must; 910_Tooteinfo: https://www.haceka.com/products/kosmos-toiletbrush-metal-8718848202037; 915_Kasutus-ja_hooldusjuhend: https://www.haceka.com/products/kosmos-toiletbrush-metal-8718848202037
Pset_DistributionFlowElementCommon - Reference: W19
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
3 x W19 | Teine korrus
4 x W19 | Esimene korrus

# IfcFlowTerminal: Shower Kit 26 (2)
In: Esimene korrus
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Santehnika - 001_Nimetus: Segisti; 002_Tähis: W8; 455_Eriomadused: Undefined; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: W8
AR_Valgusti - 001_Nimetus: Segisti; 002_Tähis: W8; 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFlowTerminal: Sink General 26 (3)
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 900_Tootja: FRANKE; 910_Tooteinfo: https://www.sansan.ee/valamud/koristajavalamu-franke-kalla.html; 915_Kasutus-ja_hooldusjuhend: https://www.sansan.ee/valamud/koristajavalamu-franke-kalla.html
AR_Santehnika - 455_Eriomadused: Koristaja valamu komplekt; 900_Tootja: FRANKE; 910_Tooteinfo: https://www.sansan.ee/valamud/koristajavalamu-franke-kalla.html; 915_Kasutus-ja_hooldusjuhend: https://www.sansan.ee/valamud/koristajavalamu-franke-kalla.html
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | AR_Valgusti, 001_Nimetus = AR_Santehnika, 001_Nimetus | AR_Valgusti, 002_Tähis = Reference = AR_Santehnika, 002_Tähis | AR_Valgusti, 905_Mudel = AR_Santehnika, 905_Mudel
W6 | Teine korrus | Koristajavalamu | W6 | 203.0499.156
W38 | Esimene korrus | Koristusvalamu | W38 | OSMA
W6 | Esimene korrus | Koristusvalamu | W6 | 203.0499.156

# IfcFlowTerminal: Standard steel toilet 2 rolls paper dispenser PR2784 (7)
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 001_Nimetus: Tualettpaber dosaator; 002_Tähis: W18; 900_Tootja: Mediclinics; 905_Mudel: PR2784B must; 910_Tooteinfo: https://www.mediclinics.com/en/toilet-paper-dispensers/1742-toilet-paper-dispensers-PR2784B.html; 915_Kasutus-ja_hooldusjuhend: https://www.mediclinics.com/en/toilet-paper-dispensers/1742-toilet-paper-dispensers-PR2784B.html
Pset_DistributionFlowElementCommon - Reference: W18
AR_Santehnika - 001_Nimetus: Tualettpaber dosaator; 002_Tähis: W18; 455_Eriomadused: Undefined; 900_Tootja: Mediclinics; 905_Mudel: PR2784B must; 910_Tooteinfo: https://www.mediclinics.com/en/toilet-paper-dispensers/1742-toilet-paper-dispensers-PR2784B.html; 915_Kasutus-ja_hooldusjuhend: https://www.mediclinics.com/en/toilet-paper-dispensers/1742-toilet-paper-dispensers-PR2784B.html
Pset_ManufacturerOccurrence - SerialNumber: PR2784C
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_ManufacturerTypeInformation - Manufacturer: Mediclinics
Name | In
3 x W18 | Teine korrus
4 x W18 | Esimene korrus

# IfcFlowTerminal: Steel paper towel C_Z folds dispenser DT2106(1) (9)
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 001_Nimetus: Paberi dosaator; 002_Tähis: W15; 900_Tootja: Mediclinics; 905_Mudel: DT2106B must; 910_Tooteinfo: https://www.mediclinics.com/en/hand-paper-towel-dispenser/1647-paper-towel-dispensers-DT2106B.html; 915_Kasutus-ja_hooldusjuhend: https://www.mediclinics.com/en/hand-paper-towel-dispenser/1647-paper-towel-dispensers-DT2106B.html
AR_Santehnika - 001_Nimetus: Paberi dosaator; 002_Tähis: W15; 455_Eriomadused: Undefined; 900_Tootja: Mediclinics; 905_Mudel: DT2106B must; 910_Tooteinfo: https://www.mediclinics.com/en/hand-paper-towel-dispenser/1647-paper-towel-dispensers-DT2106B.html; 915_Kasutus-ja_hooldusjuhend: https://www.mediclinics.com/en/hand-paper-towel-dispenser/1647-paper-towel-dispensers-DT2106B.html
Pset_DistributionFlowElementCommon - Reference: W15
Pset_ManufacturerOccurrence - SerialNumber: DT2106
Pset_ManufacturerTypeInformation - Manufacturer: Mediclinics
Name | In | Renovation Status
W15 | Teine korrus | Existing
3 x W15 | Teine korrus | New
5 x W15 | Esimene korrus | New

# IfcFlowTerminal: Vertical stainless steel swing grab bar BR0900x (2)
In: Esimene korrus
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 001_Nimetus: Inva.tugi; 002_Tähis: W25a; 900_Tootja: Mediclinics; 905_Mudel: VERTICAL SWING GRAB BAR BG0850CS; 910_Tooteinfo: https://www.mediclinics.com/en/grab-bars-and-other-accessories/1829-aisi-stainless-steel-swing-grab-bars-BG0800CS.html; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Santehnika - 001_Nimetus: Inva.tugi; 002_Tähis: W25a; 455_Eriomadused: Undefined; 900_Tootja: Mediclinics; 905_Mudel: VERTICAL SWING GRAB BAR BG0850CS; 910_Tooteinfo: https://www.mediclinics.com/en/grab-bars-and-other-accessories/1829-aisi-stainless-steel-swing-grab-bars-BG0800CS.html; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: W25a
Pset_ManufacturerOccurrence - SerialNumber: BR0900C
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_ManufacturerTypeInformation - Manufacturer: Mediclinics

# IfcFlowTerminal: Wall Hanging Rack 26 (3)
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 001_Nimetus: Nagi; 002_Tähis: W39; 900_Tootja: Häfele; 905_Mudel: 844.69.500; 910_Tooteinfo: https://www.eamf.ee/est/0-riidepuu-6-konksuga-350-x-18-x-22-mm-must; 915_Kasutus-ja_hooldusjuhend: Undefined
Pset_DistributionFlowElementCommon - Reference: W39
AR_Santehnika - 001_Nimetus: Nagi; 002_Tähis: W39; 455_Eriomadused: Undefined; 900_Tootja: Häfele; 905_Mudel: 844.69.500; 910_Tooteinfo: https://www.eamf.ee/est/0-riidepuu-6-konksuga-350-x-18-x-22-mm-must; 915_Kasutus-ja_hooldusjuhend: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
W39 | Teine korrus
2 x W39 | Esimene korrus

# IfcFlowTerminal: Wall Mounted Tap 26 (6)
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Santehnika - 455_Eriomadused: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | AR_Valgusti, 001_Nimetus = AR_Santehnika, 001_Nimetus | AR_Valgusti, 002_Tähis = AR_Santehnika, 002_Tähis = Reference | AR_Valgusti, 900_Tootja = AR_Santehnika, 900_Tootja | AR_Valgusti, 905_Mudel = AR_Santehnika, 905_Mudel | AR_Valgusti, 910_Tooteinfo = AR_Santehnika, 910_Tooteinfo | AR_Valgusti, 915_Kasutus-ja_hooldusjuhend = AR_Santehnika, 915_Kasutus-ja_hooldusjuhend
W7 | Teine korrus | Duššisegisti | W7 | Gustavsberg | Nautic Round, 150 c-c GB41215330 | https://www.gustavsberg.com/ee/tooted/segistid/dusiliftid/product/gb41215330/peadusiga-dusikomplekt-nautic-round-150-c-c-150-c-c | Unhttps://www.gustavsberg.com/ee/tooted/segistid/dusiliftid/product/gb41215330/peadusiga-dusikomplekt-nautic-round-150-c-c-150-c-cdefined
W8 | Teine korrus | Duššisegisti | W8 | Gustavsberg | Nautic Round, 150 c-c GB41215330 | https://www.gustavsberg.com/ee/tooted/segistid/dusiliftid/product/gb41215330/peadusiga-dusikomplekt-nautic-round-150-c-c-150-c-c | Unhttps://www.gustavsberg.com/ee/tooted/segistid/dusiliftid/product/gb41215330/peadusiga-dusikomplekt-nautic-round-150-c-c-150-c-cdefined
W26 | Esimene korrus | Segisti | W26 | Gustavsberg | GB41633860 33, NEW NAUTIC 216014, 1,5m voolik | https://www.gustavsberg.com/ee/tooted/gustavsberg-varuosad/segistite-varuosad/valamusegistid/product/gb41633860-33/kasiduss-isesulguv-5 https://www.feb.ee/et/dusisegisti-gustavsberg-new-nautic-kroom
W7 | Esimene korrus | Duššisegisti | W7 | Oras | Saga 3915Y | https://www.oras.com/ee/tooted/disaini-sarjad/oras-saga/valamusegisti/3915Y | https://www.oras.com/ee/tooted/disaini-sarjad/oras-saga/valamusegisti/3915Y
2 x W7 | Esimene korrus | Segisti | W7 | Gustavsberg | Oras Saga 3915Y | https://www.oras.com/ee/tooted/disaini-sarjad/oras-saga/valamusegisti/3915Y | https://www.oras.com/ee/tooted/disaini-sarjad/oras-saga/valamusegisti/3915Y

# IfcFlowTerminal: katrin_bin_25_litre_steel (2)
In: Teine korrus
Classification: 1.18 IfcSanitaryTerminalType (santehnika) (RKAS BIM + ARCHICAD Classification)
AR_Valgusti - 001_Nimetus: Prügikast; 002_Tähis: W16; 900_Tootja: Mediclinics; 905_Mudel: PPA2279B must; 910_Tooteinfo: https://www.mediclinics.com/en/trash-can-pedal-bins-and-sanitary-bin/1776-open-bins-PPA2279B.html; 915_Kasutus-ja_hooldusjuhend: https://www.mediclinics.com/en/trash-can-pedal-bins-and-sanitary-bin/1776-open-bins-PPA2279B.html
Pset_DistributionFlowElementCommon - Reference: W16
AR_Santehnika - 001_Nimetus: Prügikast; 002_Tähis: W16; 455_Eriomadused: Undefined; 900_Tootja: Mediclinics; 905_Mudel: PPA2279B must; 910_Tooteinfo: https://www.mediclinics.com/en/trash-can-pedal-bins-and-sanitary-bin/1776-open-bins-PPA2279B.html; 915_Kasutus-ja_hooldusjuhend: https://www.mediclinics.com/en/trash-can-pedal-bins-and-sanitary-bin/1776-open-bins-PPA2279B.html
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: 5932 (2)
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
Pset_QuantityTakeOff - Reference: 5932
AR_Mööbel - 001_Nimetus: M7; 002_Tähis: 5932; 900_Tootja: Undefined; 905_Mudel: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Bed 01 26 (2)
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Voodi; 900_Tootja: Deekhoorn, Sleepwell; 905_Mudel: connect corner bed + madrats: blue-pocket, top-profiled-foam
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | Reference = 002_Tähis
M24 | M24
M25 | M25

# IfcFurnishingElement: Book Shelf 01 17 (7)
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
Name | 001_Nimetus | 002_Tähis = Reference | 900_Tootja | 905_Mudel | Renovation Status
2 x M24+ | M24+ | M24 | Deekhoorn, Sleepwell | connect corner bed + madrats: blue-pocket, top-profiled-foam | New
2 x M25 | M25 | M25 | Deekhoorn, Sleepwell | connect corner bed + madrats: blue-pocket, top-profiled-foam | New
M42 | Köögimööbel | M42 | Erijoonis | Undefined | Existing
M43 | Riiul | M43 | Erijoonis | Undefined | Existing
Mööbel | Mööbel | Book Shelf 01 17 | Undefined | Undefined | Existing

# IfcFurnishingElement: Bookshelf 02 26 (49)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | 001_Nimetus | 002_Tähis = Reference | 900_Tootja | 905_Mudel
M31 | Teine korrus | Riiul | M31 | Ikea | JOSTEIN
M34 | Teine korrus | Kapp | M34 | Laoekspert | 30-211040V
2 x M33 | Esimene korrus | Kapp | M33 | Laoekspert | 30-217550Z
13 x M35 | Esimene korrus | Laoriiul | M35 | Laoekspert | 30-211060V
26 x M36 | Esimene korrus | Laoriiul | M36 | Laoekspert | 30-211060VJ
3 x M38 | Esimene korrus | Nagi | M38 | Rowico | Hemp, 119545
3 x M40 | Esimene korrus | Nagi | M40 | Erijoonis

# IfcFurnishingElement: Cabinet Base MultiDrawer 24 (3)
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Köögimööbel; 002_Tähis: M42; 900_Tootja: Erijoonis; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: M42
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Cabinet Base Single Door 24, M42
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification); 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Köögimööbel; 002_Tähis: M42; 900_Tootja: Erijoonis; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: M42
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Cabinet Tall Single Door 17, M42
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_QuantityTakeOff - Reference: M42
AR_Mööbel - 001_Nimetus: Köögimööbel; 002_Tähis: M42; 900_Tootja: Erijoonis; 905_Mudel: Undefined

# IfcFurnishingElement: Cabinet Tall Single Door 24, M41
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Kapp; 002_Tähis: M41; 900_Tootja: Erijoonis; 905_Mudel: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_QuantityTakeOff - Reference: M41

# IfcFurnishingElement: Cabinet Wall Single Door 17, M42
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
Pset_QuantityTakeOff - Reference: M42
AR_Mööbel - 001_Nimetus: Köögimööbel; 002_Tähis: M42; 900_Tootja: Erijoonis; 905_Mudel: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: Car 04 26, Mööbel
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Mööbel; 002_Tähis: Car 04 26; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Car 04 26
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Chair 10 26 (98)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
Name | In | 001_Nimetus | 002_Tähis = Reference | 900_Tootja | 905_Mudel | Renovation Status
21 x M2 | Teine korrus | Tool | M2 | axona aichi | TIPO-3P-SX | New
16 x M3 | Teine korrus | Tool | M3 | axona aichi | TIPO-1M-NST | New
14 x M4 | Teine korrus | Tool | Chair 10 26 | axona aichI | TIPO-3M-SX | New
10 x M2 | Esimene korrus | Tool | M2 | axona aichi | TIPO-3P-SX | New
5 x M3 | Esimene korrus | Tool | M3 | axona aichi | TIPO-1M-NST | New
30 x M4 | Esimene korrus | Tool | M4 | axona aichI | TIPO-3M-SX | New
2 x Olemasolev | Esimene korrus | Olemasolev | Chair 10 26 | Undefined | Undefined | Existing

# IfcFurnishingElement: Coat Rack 02 26 (15)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Nagi; 002_Tähis: M8; 900_Tootja: Profim; 905_Mudel: Seven
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_QuantityTakeOff - Reference: M8
Name | In
10 x M8 | Teine korrus
5 x M8 | Esimene korrus

# IfcFurnishingElement: Coffee Maker 26, M42
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Köögimööbel; 002_Tähis: M42; 900_Tootja: Erijoonis; 905_Mudel: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_QuantityTakeOff - Reference: M42

# IfcFurnishingElement: Coffee Table 03 26, M15
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Laud; 002_Tähis: M15; 900_Tootja: Scabdesign; 905_Mudel: Metropolis XL
Pset_QuantityTakeOff - Reference: M15
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Coffee Table 06 26 (2)
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Laud; 002_Tähis: M14; 900_Tootja: Paged; 905_Mudel: Tuk-s
Pset_QuantityTakeOff - Reference: M14
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Copier 26, Mööbel
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Printer; 002_Tähis: Copier 26; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Copier 26
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Designer Chair 14 26 (3)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Tool; 002_Tähis: M6; 900_Tootja: Scab; 905_Mudel: Lisa Lounge 2858
Pset_QuantityTakeOff - Reference: M6
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Dishwasher Built-in 26, M42
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Köögimööbel; 002_Tähis: M42; 900_Tootja: Erijoonis; 905_Mudel: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_QuantityTakeOff - Reference: M42

# IfcFurnishingElement: Dryer 26 (2)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Pesumasin; 002_Tähis: Dryer 26; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Dryer 26
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Electronics_Appliances_Electrolux_Electrolux-Induction-Full-Hob-Domino-Bla(1), M42
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
Pset_QuantityTakeOff - Reference: M42
AR_Mööbel - 001_Nimetus: Köögimööbel; 002_Tähis: M42; 900_Tootja: Erijoonis; 905_Mudel: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: Flat Panel TV 26 (15)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 002_Tähis: Flat Panel TV 26; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Flat Panel TV 26
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | 001_Nimetus
8 x Mööbel | Teine korrus | Ekraan
6 x Mööbel | Teine korrus | Mööbel
Mööbel | Esimene korrus | Ekraan

# IfcFurnishingElement: Furnishing 1, F2540 - Shredder, Paper, Security
In: Teine korrus
Classification: Furnishing (ARCHICAD Classification); 1.10 IfcFurnitureType (mööbel) (_RKAS BIM + ARCHICAD Classification); 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification); Material: IFC Building Material
ePset_BIMobject_Lena - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): F2540 - Shredder, Paper, Security; SKU (BO_prodsku): F2540; ManufacturName (BO_Manufac): SEPS2BIM; ManufacturCountry (BO_mancont): United States; DesignCountry (BO_designcont): United States; PublishDate (BO_publisdat): 2014-08-12; EditionNumber (BO_edinum): 1; Width (BO_width): 430; Height (BO_height): 660; Depth (BO_depth): 330; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/seps2bim/product/F2540; ProductDataUrl (BO_prodaturl): bimobject.com/seps2bim/product/F2540; IfcClassification (BO_ifcclas): Furnishing Element; RegionNorthAmerica (BO_northamerica): US
AR_Mööbel - 001_Nimetus: F2540 - Shredder, Paper, Security; 002_Tähis: Furnishing 1; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Furnishing 1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: Furniture_Armchairs_Swedese_Amstelle-easy-chair-Wood-legs(1) (5)
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Tugitool; 002_Tähis: M5; 900_Tootja: Fotel; 905_Mudel: M-BIG TUK
Pset_QuantityTakeOff - Reference: M5
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: KON-00_GENEERILINE - KONSTRUKTSIOON 20 (3)
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification); Material: KON-00_GENEERILINE - KONSTRUKTSIOON
AR_Mööbel - 002_Tähis: KON-00; 900_Tootja: Undefined; 905_Mudel: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_QuantityTakeOff - Reference: KON-00
Name | 001_Nimetus
2 x SAD-1 | SAD-1
SS-55 | SS-55

# IfcFurnishingElement: KON-00_GENEERILINE - KONSTRUKTSIOON 500 (2)
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification); Material: KON-00_GENEERILINE - KONSTRUKTSIOON
AR_Mööbel - 001_Nimetus: Kapp; 002_Tähis: KON-00; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: KON-00
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Klaas, duššiklaas
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification); Material: Klaas
AR_Mööbel - 001_Nimetus: duššiklaas; 002_Tähis: Klaas; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Klaas
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Laptop 26 (3)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
Pset_QuantityTakeOff - Reference: Laptop 26
AR_Mööbel - 001_Nimetus: Mööbel; 002_Tähis: Laptop 26; 900_Tootja: Undefined; 905_Mudel: Undefined
Name | In | Renovation Status
Mööbel | Teine korrus | Existing
2 x Mööbel | Esimene korrus | New

# IfcFurnishingElement: Lockers 26 (7)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Riietuskapp; 900_Tootja: CP Evolo
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 002_Tähis = Reference | 905_Mudel
4 x M27 | M27 | 50-48050-32
3 x M28 | M28 | 50-48050-22

# IfcFurnishingElement: Microwave Oven 26, M42
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Köögimööbel; 002_Tähis: M42; 900_Tootja: Erijoonis; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: M42
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Mirror 26 (7)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Peegel
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | 002_Tähis = Reference | 900_Tootja | 905_Mudel
M32 | Teine korrus | M32 | Andresglaas | Yeti Custom
5 x M26 | Esimene korrus | M26 | Actona group | Selje
M32 | Esimene korrus | M32 | Andresglaas | Yeti Custom

# IfcFurnishingElement: Monitor (LCD) 26 (31)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Mööbel; 002_Tähis: Monitor (LCD) 26; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Monitor (LCD) 26
Name | In | Renovation Status
19 x Mööbel | Teine korrus | New
10 x Mööbel | Esimene korrus | New
2 x Mööbel | Esimene korrus | Existing

# IfcFurnishingElement: Office Cabinet 26 (12)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 002_Tähis: Office Cabinet 26; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Office Cabinet 26
Name | 001_Nimetus | Renovation Status
2 x Mööbel | Expo | New
9 x Olemasolev | Vitriin | Existing
Olemasolev | Olemasolev | Existing

# IfcFurnishingElement: Office Chair 06 26 (25)
Classification: 1.02 IfcBuildingElementProxyType (objekt) (RKAS BIM + ARCHICAD Classification)
AR_Ruum - 110_Tüüp: Undefined; 125_Turvatsoon: Undefined
AR - 001_Nimetus: Mööbel; 002_Tähis: Furniture_Chairs-Stools-Benches_CIDER-LA-MANUFACTURE_I-Task-Chaise-de-bureau
AR_300-396 - 300_Tähis: Furniture_Chairs-Stools-Benches_CIDER-LA-MANUFACTURE_I-Task-Chaise-de-bureau: 654x1,017; 305_Ava_mõõt: 654x1,017; 308_Ruumi number: New Option; 310_Materjal: Undefined; 315_Avanemine (Avanemise kirjeldus): Undefined; 315_Avanemine: Undefined; 320_Klaas: Undefined; 325_Helipidavus: Undefined; 330_Tulekindlus: Undefined; 332_Turvaklass: Undefined; 333_Suitsueemaldus: Undefined; 335_Välispiire: no; 341_Soojusläbivus (raam, avatäide vms): 0; 350_Klaaspakett: Undefined; 360_Ratastooliga: no; 365_Isesulguv: no; 370_Evakuatsiooniväljapääs: True; 371_Evakuatsioonisulused/inimeste arv: 0.00; 372_Kaardilugeja: New Option; 378_Lävepakk: Undefined; 379_Käepide: Undefined; 380_Lukustus: Undefined; 381_Lukuraam: Undefined; 382_Südamik: Undefined; 383_Vasturaud: Undefined; 384_Sulgur: Undefined; 395_Veeplekk: Undefined; 396_Aknalaud: Undefined
AR_400-455 - 455_Eriomadused: Kahesüsteemne, kõrgus 420mm; 400_Võimsus: 0; 405_Paigaldusviis: Undefined; 410_IP_klass: Undefined; 450_Paigaldus: Põrandapealne
AR_500-550 - 500_Kandev: no
AR_900-915 - 900_Tootja: Undefined; 905_Mudel: Undefined; 910_Tooteinfo: Undefined; 915_Kasutus-ja_hooldusjuhend: Undefined
AR_Hoone - 035_Sprinkler: no
AR_Korrus - 060_Korruse_nimi: Undefined; 065_Korruse_number: Undefined; 070_Maapealne: no
AR_Kinnistu - 010_Katastritunnus: RKAS Katastritunnus -> IFC Project Manager
AR_001-002 - 001_Nimetus: WC-pott; 002_Tüüp: WC2; 003_Materjal: Sanitaarportselan
AR_Tsoon - 080_Tähis: Undefined; 085_Tuletõkkesektsioon: Undefined
MANUFACTURING - Product Website: www.graphisoft.com
PRODUCT DESCRIPTION (Expression) - Product location: Name of project: Ilmavaatlusjaama peahoone rekonstrueerimineSite: RKAS Kinnistu Nimi -> SOLIBRI Story: Esimene korrus Room:; Hotlinked Door Context ID: Mööbel; Stair Subelements - Numerical IDs: Mööbel
AR_200-245 - 205_Tüüp: Furniture_Chairs-Stools-Benches_CIDER-LA-MANUFACTURE_I-Task-Chaise-de-bureau; 215_Tulekindlusklass: Undefined; 220_Viimistlus: Undefined; 230_Niiskuskindel: no; 235_Karkass: Undefined; 240_Märghõõrdekindlus: Undefined; 245_Aluspind: Undefined; 206_Tüüp: Mööbel
AR_Mööbel - 001_Nimetus: Töötool; 002_Tähis: M1; 900_Tootja: actiu
Pset_QuantityTakeOff - Reference: M1
Name | In | 905_Mudel | Renovation Status
15 x Mööbel | Teine korrus | stay serie 30+ peatugi | New
2 x Mööbel | Esimene korrus | stay serie 30 | Existing
8 x Mööbel | Esimene korrus | stay serie 30+ peatugi | New

# IfcFurnishingElement: Office Desk Rect 26 (44)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
Name | In | 001_Nimetus | 002_Tähis = Reference | 900_Tootja | 905_Mudel | Renovation Status
12 x M12 | Teine korrus | Kontorilaud | M12 | Thulema | Särts+ Dezibel lauasirm | New
M12 | Teine korrus | Kontorilaud | Office Desk Rect 26 | Undefined | Undefined | New
6 x M13 | Teine korrus | Laud | M13 | ISKU | Move | New
2 x M13a | Teine korrus | Laud | M13a | ISKU | Move | New
3 x M17 | Teine korrus | Laud | M17 | Kave home | curie desk CC1342M87 | New
M20 | Teine korrus | Kontorilaud | M20 | Thulema | Thor TL-1 | New
2 x M47 | Teine korrus | Kontorilaud | M47 | Thulema | Särts | New
8 x M12 | Esimene korrus | Kontorilaud | M12 | Thulema | Särts+ Dezibel lauasirm | New
2 x M20 | Esimene korrus | Kontorilaud | M20 | Thulema | Thor TL-1 | New
3 x Olemasolev | Esimene korrus | Kontorilaud | Office Desk Rect 26 | Undefined | Undefined | Existing
3 x Olemasolev | Esimene korrus | Olemasolev | Office Desk Rect 26 | Undefined | Undefined | Existing
Olemasolev | Esimene korrus | Laud | Office Desk Rect 26 | Undefined | Undefined | Existing

# IfcFurnishingElement: Picture 26, Interaktiivne sein
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Interaktiivne sein; 002_Tähis: Picture 26; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Picture 26
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Projector 26 (2)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Mööbel; 002_Tähis: Projector 26; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Projector 26
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Projector Screen 17 (2)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Mööbel; 002_Tähis: Projector Screen 17; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Projector Screen 17
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: RAL 9003 Signal white_sile (18)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification); Material: RAL 9003 Signal white_sile
AR_Mööbel - 001_Nimetus: Kardin; 002_Tähis: Ka1; 900_Tootja: Eritöö; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Ka1
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
16 x Ka5 | Teine korrus
2 x Ka1 | Esimene korrus

# IfcFurnishingElement: Range Hood #1043, M42
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Köögimööbel; 002_Tähis: M42; 900_Tootja: Erijoonis; 905_Mudel: Undefined
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Pset_QuantityTakeOff - Reference: M42

# IfcFurnishingElement: Rectangular Table 01 26 (14)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Pink
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | 002_Tähis = Reference | 900_Tootja | 905_Mudel
M30 | Teine korrus | M30 | Vitamindesign | BENCH MENA 4
2 x M10 | Esimene korrus | M10 | Eritöö | Undefined
4 x M27 | Esimene korrus | M27 | CP Evolo | 50-48050-32
3 x M28 | Esimene korrus | M28 | CP Evolo | 50-48050-40
2 x M30 | Esimene korrus | M30 | Vitamindesign | BENCH MENA 4
2 x M9 | Esimene korrus | M9 | House nordic | Barcelona

# IfcFurnishingElement: Refrigerator 26 (3)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Kapp; 002_Tähis: Refrigerator 26; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Refrigerator 26
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Round Table 01 26 (3)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Laud
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 002_Tähis = Reference | 900_Tootja | 905_Mudel
M16 | M15 | Kave home | Aiguablava
2 x M29 | M29 | Tool.ee | Tripe Fixed 5003, Finger-joined oak Ø 600

# IfcFurnishingElement: Round Table 02 26, M18
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Laud; 002_Tähis: M18; 900_Tootja: Scabdesign, Pedrali; 905_Mudel: Jalg: maxi-domino, Plaat: copmpact 247 d:990mm
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_QuantityTakeOff - Reference: M18

# IfcFurnishingElement: SA- Laminaat SM2(kollane laminaat) (14)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification); Material: SA- Laminaat SM2(kollane laminaat)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | 001_Nimetus | 002_Tähis = Reference | 900_Tootja | 905_Mudel
L124 | Teine korrus | Laud | L123 | Eritöö | Undefined
L125 | Teine korrus | Laud | L123 | Eritöö | Undefined
L126 | Teine korrus | Laud | L123 | Eritöö | Undefined
6 x M11 | Teine korrus | Kaablikate | M46 | Eritöö | Undefined
M19 | Teine korrus | Laud | M19 | Eritöö, Häfele | Art.no.287.31.765 , abet laminati 1801 giallo ocra (sinep); fin sei
4 x M39 | Esimene korrus | Nagi | M39 | Eritöö | Undefined

# IfcFurnishingElement: Sanitary_Accessories_DELABIE_4043BK-Matte-black-stainless-steel-coat (38)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Nagi; 900_Tootja: Haceka; 905_Mudel: Kosmos 1208731
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | 002_Tähis = Reference
34 x M39 | M39
4 x W13 | W13

# IfcFurnishingElement: Sanitary_Dryers_Mediclinics_Machflow-hair-dryer-SC0009x_220V(1) (2)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Föön; 002_Tähis: Sanitary_Dryers_Mediclinics_Machflow-hair-dryer-SC0009x_220V(1); 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_ManufacturerTypeInformation - Manufacturer: Mediclinics
Pset_QuantityTakeOff - Reference: Sanitary_Dryers_Mediclinics_Machflow-hair-dryer-SC0009x_220V(1)
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_ManufacturerOccurrence - SerialNumber: SC0009S

# IfcFurnishingElement: Sofa 26, Olemasolev
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Olemasolev; 002_Tähis: Sofa 26; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Sofa 26
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcFurnishingElement: Underdesk Drawer 26 (25)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Sahtliboks
Name | In | Reference = 002_Tähis | Renovation Status | 900_Tootja | 905_Mudel
15 x M12a | Teine korrus | M12a | New | Thulema | T-SR3L
8 x M12a | Esimene korrus | M12a | New | Thulema | T-SR3L
2 x Mööbel | Esimene korrus | Underdesk Drawer 26 | Existing | Undefined | Undefined

# IfcFurnishingElement: VKK-01_Vesi (7)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification); Material: VKK-01_Vesi
Pset_QuantityTakeOff - Reference: L123
AC_Pset_RenovationAndPhasing - Renovation Status: New
AR_Mööbel - 001_Nimetus: Seinapaneel; 002_Tähis: L123; 900_Tootja: Vaga; 905_Mudel: Vesi

# IfcFurnishingElement: Vertical Blinds 26 (26)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Laoriiul; 002_Tähis: M35; 900_Tootja: Laoekspert; 905_Mudel: 30-211060V
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_QuantityTakeOff - Reference: M35
Name | In
11 x Ka1 | Teine korrus
12 x Ka1 | Esimene korrus
Ka2 | Esimene korrus
Ka3 | Esimene korrus
Ka4 | Esimene korrus

# IfcFurnishingElement: Wall Cabinet 26 (2)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Prügikast; 900_Tootja: Made Design
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In | 002_Tähis = Reference | 905_Mudel
M45 | Teine korrus | M45 | Zell, ZEL03P
M44 | Esimene korrus | M44 | Barilea BAS10

# IfcFurnishingElement: Wardrobe 01 26, M22
In: Teine korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Kapp; 002_Tähis: M22; 900_Tootja: Deekhorn; 905_Mudel: PURE 3 DRS WARDROBE SPLITDOOR PINE DUST [FSC] 379553-BET
Pset_QuantityTakeOff - Reference: M22
AC_Pset_RenovationAndPhasing - Renovation Status: New

# IfcFurnishingElement: Wardrobe Variable 26 (18)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Kapp; 002_Tähis: M21; 900_Tootja: Thulema; 905_Mudel: K4 U2L/J
Pset_QuantityTakeOff - Reference: M21
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
13 x M21 | Teine korrus
5 x M21 | Esimene korrus

# IfcFurnishingElement: Washer 26 (3)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Pesumasin; 002_Tähis: Washer 26; 900_Tootja: Undefined; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: Washer 26
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name
2 x Mööbel
Pesumasin

# IfcFurnishingElement: katrin_bin_25_litre_steel (4)
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Prügikast; 002_Tähis: W16; 900_Tootja: Mediclinics; 905_Mudel: PPA2279B must
Pset_QuantityTakeOff - Reference: W16
AC_Pset_RenovationAndPhasing - Renovation Status: New
Name | In
W16 | Teine korrus
3 x W16 | Esimene korrus

# IfcFurnishingElement: wallshelf (2)
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Riiul; 002_Tähis: M23; 900_Tootja: Seinariiul Wood; 905_Mudel: Seinariiul Wood, tamm 60 cm, AQ-377838
AC_Pset_RenovationAndPhasing - Renovation Status: New
Pset_QuantityTakeOff - Reference: M23

# IfcFurnishingElement: wallshelf(1), M41
In: Esimene korrus
Classification: 1.11 IfcFurnitureType (mööbel) (RKAS BIM + ARCHICAD Classification)
AR_Mööbel - 001_Nimetus: Töötasapind; 002_Tähis: M41; 900_Tootja: Erijoonis; 905_Mudel: Undefined
Pset_QuantityTakeOff - Reference: M41
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
